* Nettran: AMD.64 Release B-2008.09.SP5.HF2.26004 2012/07/19
* Created:  6/23/2016  12:26
* Options: -verilog netlist.v -outName netlist.sp -verilog-b1 VDD -verilog-b0 GND -outType spice

.GLOBAL VDD GND

.SUBCKT InstructionBuffer clk reset flush_i stall_i decodeReady_i decodedVector_i[7]
+ decodedVector_i[6] decodedVector_i[5] decodedVector_i[4] decodedVector_i[3] decodedVector_i[2]
+ decodedVector_i[1] decodedVector_i[0] decodedPacket0_i[125] decodedPacket0_i[124]
+ decodedPacket0_i[123] decodedPacket0_i[122] decodedPacket0_i[121] decodedPacket0_i[120]
+ decodedPacket0_i[119] decodedPacket0_i[118] decodedPacket0_i[117] decodedPacket0_i[116]
+ decodedPacket0_i[115] decodedPacket0_i[114] decodedPacket0_i[113] decodedPacket0_i[112]
+ decodedPacket0_i[111] decodedPacket0_i[110] decodedPacket0_i[109] decodedPacket0_i[108]
+ decodedPacket0_i[107] decodedPacket0_i[106] decodedPacket0_i[105] decodedPacket0_i[104]
+ decodedPacket0_i[103] decodedPacket0_i[102] decodedPacket0_i[101] decodedPacket0_i[100]
+ decodedPacket0_i[99] decodedPacket0_i[98] decodedPacket0_i[97] decodedPacket0_i[96]
+ decodedPacket0_i[95] decodedPacket0_i[94] decodedPacket0_i[93] decodedPacket0_i[92]
+ decodedPacket0_i[91] decodedPacket0_i[90] decodedPacket0_i[89] decodedPacket0_i[88]
+ decodedPacket0_i[87] decodedPacket0_i[86] decodedPacket0_i[85] decodedPacket0_i[84]
+ decodedPacket0_i[83] decodedPacket0_i[82] decodedPacket0_i[81] decodedPacket0_i[80]
+ decodedPacket0_i[79] decodedPacket0_i[78] decodedPacket0_i[77] decodedPacket0_i[76]
+ decodedPacket0_i[75] decodedPacket0_i[74] decodedPacket0_i[73] decodedPacket0_i[72]
+ decodedPacket0_i[71] decodedPacket0_i[70] decodedPacket0_i[69] decodedPacket0_i[68]
+ decodedPacket0_i[67] decodedPacket0_i[66] decodedPacket0_i[65] decodedPacket0_i[64]
+ decodedPacket0_i[63] decodedPacket0_i[62] decodedPacket0_i[61] decodedPacket0_i[60]
+ decodedPacket0_i[59] decodedPacket0_i[58] decodedPacket0_i[57] decodedPacket0_i[56]
+ decodedPacket0_i[55] decodedPacket0_i[54] decodedPacket0_i[53] decodedPacket0_i[52]
+ decodedPacket0_i[51] decodedPacket0_i[50] decodedPacket0_i[49] decodedPacket0_i[48]
+ decodedPacket0_i[47] decodedPacket0_i[46] decodedPacket0_i[45] decodedPacket0_i[44]
+ decodedPacket0_i[43] decodedPacket0_i[42] decodedPacket0_i[41] decodedPacket0_i[40]
+ decodedPacket0_i[39] decodedPacket0_i[38] decodedPacket0_i[37] decodedPacket0_i[36]
+ decodedPacket0_i[35] decodedPacket0_i[34] decodedPacket0_i[33] decodedPacket0_i[32]
+ decodedPacket0_i[31] decodedPacket0_i[30] decodedPacket0_i[29] decodedPacket0_i[28]
+ decodedPacket0_i[27] decodedPacket0_i[26] decodedPacket0_i[25] decodedPacket0_i[24]
+ decodedPacket0_i[23] decodedPacket0_i[22] decodedPacket0_i[21] decodedPacket0_i[20]
+ decodedPacket0_i[19] decodedPacket0_i[18] decodedPacket0_i[17] decodedPacket0_i[16]
+ decodedPacket0_i[15] decodedPacket0_i[14] decodedPacket0_i[13] decodedPacket0_i[12]
+ decodedPacket0_i[11] decodedPacket0_i[10] decodedPacket0_i[9] decodedPacket0_i[8]
+ decodedPacket0_i[7] decodedPacket0_i[6] decodedPacket0_i[5] decodedPacket0_i[4]
+ decodedPacket0_i[3] decodedPacket0_i[2] decodedPacket0_i[1] decodedPacket0_i[0]
+ decodedPacket1_i[125] decodedPacket1_i[124] decodedPacket1_i[123] decodedPacket1_i[122]
+ decodedPacket1_i[121] decodedPacket1_i[120] decodedPacket1_i[119] decodedPacket1_i[118]
+ decodedPacket1_i[117] decodedPacket1_i[116] decodedPacket1_i[115] decodedPacket1_i[114]
+ decodedPacket1_i[113] decodedPacket1_i[112] decodedPacket1_i[111] decodedPacket1_i[110]
+ decodedPacket1_i[109] decodedPacket1_i[108] decodedPacket1_i[107] decodedPacket1_i[106]
+ decodedPacket1_i[105] decodedPacket1_i[104] decodedPacket1_i[103] decodedPacket1_i[102]
+ decodedPacket1_i[101] decodedPacket1_i[100] decodedPacket1_i[99] decodedPacket1_i[98]
+ decodedPacket1_i[97] decodedPacket1_i[96] decodedPacket1_i[95] decodedPacket1_i[94]
+ decodedPacket1_i[93] decodedPacket1_i[92] decodedPacket1_i[91] decodedPacket1_i[90]
+ decodedPacket1_i[89] decodedPacket1_i[88] decodedPacket1_i[87] decodedPacket1_i[86]
+ decodedPacket1_i[85] decodedPacket1_i[84] decodedPacket1_i[83] decodedPacket1_i[82]
+ decodedPacket1_i[81] decodedPacket1_i[80] decodedPacket1_i[79] decodedPacket1_i[78]
+ decodedPacket1_i[77] decodedPacket1_i[76] decodedPacket1_i[75] decodedPacket1_i[74]
+ decodedPacket1_i[73] decodedPacket1_i[72] decodedPacket1_i[71] decodedPacket1_i[70]
+ decodedPacket1_i[69] decodedPacket1_i[68] decodedPacket1_i[67] decodedPacket1_i[66]
+ decodedPacket1_i[65] decodedPacket1_i[64] decodedPacket1_i[63] decodedPacket1_i[62]
+ decodedPacket1_i[61] decodedPacket1_i[60] decodedPacket1_i[59] decodedPacket1_i[58]
+ decodedPacket1_i[57] decodedPacket1_i[56] decodedPacket1_i[55] decodedPacket1_i[54]
+ decodedPacket1_i[53] decodedPacket1_i[52] decodedPacket1_i[51] decodedPacket1_i[50]
+ decodedPacket1_i[49] decodedPacket1_i[48] decodedPacket1_i[47] decodedPacket1_i[46]
+ decodedPacket1_i[45] decodedPacket1_i[44] decodedPacket1_i[43] decodedPacket1_i[42]
+ decodedPacket1_i[41] decodedPacket1_i[40] decodedPacket1_i[39] decodedPacket1_i[38]
+ decodedPacket1_i[37] decodedPacket1_i[36] decodedPacket1_i[35] decodedPacket1_i[34]
+ decodedPacket1_i[33] decodedPacket1_i[32] decodedPacket1_i[31] decodedPacket1_i[30]
+ decodedPacket1_i[29] decodedPacket1_i[28] decodedPacket1_i[27] decodedPacket1_i[26]
+ decodedPacket1_i[25] decodedPacket1_i[24] decodedPacket1_i[23] decodedPacket1_i[22]
+ decodedPacket1_i[21] decodedPacket1_i[20] decodedPacket1_i[19] decodedPacket1_i[18]
+ decodedPacket1_i[17] decodedPacket1_i[16] decodedPacket1_i[15] decodedPacket1_i[14]
+ decodedPacket1_i[13] decodedPacket1_i[12] decodedPacket1_i[11] decodedPacket1_i[10]
+ decodedPacket1_i[9] decodedPacket1_i[8] decodedPacket1_i[7] decodedPacket1_i[6]
+ decodedPacket1_i[5] decodedPacket1_i[4] decodedPacket1_i[3] decodedPacket1_i[2]
+ decodedPacket1_i[1] decodedPacket1_i[0] decodedPacket2_i[125] decodedPacket2_i[124]
+ decodedPacket2_i[123] decodedPacket2_i[122] decodedPacket2_i[121] decodedPacket2_i[120]
+ decodedPacket2_i[119] decodedPacket2_i[118] decodedPacket2_i[117] decodedPacket2_i[116]
+ decodedPacket2_i[115] decodedPacket2_i[114] decodedPacket2_i[113] decodedPacket2_i[112]
+ decodedPacket2_i[111] decodedPacket2_i[110] decodedPacket2_i[109] decodedPacket2_i[108]
+ decodedPacket2_i[107] decodedPacket2_i[106] decodedPacket2_i[105] decodedPacket2_i[104]
+ decodedPacket2_i[103] decodedPacket2_i[102] decodedPacket2_i[101] decodedPacket2_i[100]
+ decodedPacket2_i[99] decodedPacket2_i[98] decodedPacket2_i[97] decodedPacket2_i[96]
+ decodedPacket2_i[95] decodedPacket2_i[94] decodedPacket2_i[93] decodedPacket2_i[92]
+ decodedPacket2_i[91] decodedPacket2_i[90] decodedPacket2_i[89] decodedPacket2_i[88]
+ decodedPacket2_i[87] decodedPacket2_i[86] decodedPacket2_i[85] decodedPacket2_i[84]
+ decodedPacket2_i[83] decodedPacket2_i[82] decodedPacket2_i[81] decodedPacket2_i[80]
+ decodedPacket2_i[79] decodedPacket2_i[78] decodedPacket2_i[77] decodedPacket2_i[76]
+ decodedPacket2_i[75] decodedPacket2_i[74] decodedPacket2_i[73] decodedPacket2_i[72]
+ decodedPacket2_i[71] decodedPacket2_i[70] decodedPacket2_i[69] decodedPacket2_i[68]
+ decodedPacket2_i[67] decodedPacket2_i[66] decodedPacket2_i[65] decodedPacket2_i[64]
+ decodedPacket2_i[63] decodedPacket2_i[62] decodedPacket2_i[61] decodedPacket2_i[60]
+ decodedPacket2_i[59] decodedPacket2_i[58] decodedPacket2_i[57] decodedPacket2_i[56]
+ decodedPacket2_i[55] decodedPacket2_i[54] decodedPacket2_i[53] decodedPacket2_i[52]
+ decodedPacket2_i[51] decodedPacket2_i[50] decodedPacket2_i[49] decodedPacket2_i[48]
+ decodedPacket2_i[47] decodedPacket2_i[46] decodedPacket2_i[45] decodedPacket2_i[44]
+ decodedPacket2_i[43] decodedPacket2_i[42] decodedPacket2_i[41] decodedPacket2_i[40]
+ decodedPacket2_i[39] decodedPacket2_i[38] decodedPacket2_i[37] decodedPacket2_i[36]
+ decodedPacket2_i[35] decodedPacket2_i[34] decodedPacket2_i[33] decodedPacket2_i[32]
+ decodedPacket2_i[31] decodedPacket2_i[30] decodedPacket2_i[29] decodedPacket2_i[28]
+ decodedPacket2_i[27] decodedPacket2_i[26] decodedPacket2_i[25] decodedPacket2_i[24]
+ decodedPacket2_i[23] decodedPacket2_i[22] decodedPacket2_i[21] decodedPacket2_i[20]
+ decodedPacket2_i[19] decodedPacket2_i[18] decodedPacket2_i[17] decodedPacket2_i[16]
+ decodedPacket2_i[15] decodedPacket2_i[14] decodedPacket2_i[13] decodedPacket2_i[12]
+ decodedPacket2_i[11] decodedPacket2_i[10] decodedPacket2_i[9] decodedPacket2_i[8]
+ decodedPacket2_i[7] decodedPacket2_i[6] decodedPacket2_i[5] decodedPacket2_i[4]
+ decodedPacket2_i[3] decodedPacket2_i[2] decodedPacket2_i[1] decodedPacket2_i[0]
+ decodedPacket3_i[125] decodedPacket3_i[124] decodedPacket3_i[123] decodedPacket3_i[122]
+ decodedPacket3_i[121] decodedPacket3_i[120] decodedPacket3_i[119] decodedPacket3_i[118]
+ decodedPacket3_i[117] decodedPacket3_i[116] decodedPacket3_i[115] decodedPacket3_i[114]
+ decodedPacket3_i[113] decodedPacket3_i[112] decodedPacket3_i[111] decodedPacket3_i[110]
+ decodedPacket3_i[109] decodedPacket3_i[108] decodedPacket3_i[107] decodedPacket3_i[106]
+ decodedPacket3_i[105] decodedPacket3_i[104] decodedPacket3_i[103] decodedPacket3_i[102]
+ decodedPacket3_i[101] decodedPacket3_i[100] decodedPacket3_i[99] decodedPacket3_i[98]
+ decodedPacket3_i[97] decodedPacket3_i[96] decodedPacket3_i[95] decodedPacket3_i[94]
+ decodedPacket3_i[93] decodedPacket3_i[92] decodedPacket3_i[91] decodedPacket3_i[90]
+ decodedPacket3_i[89] decodedPacket3_i[88] decodedPacket3_i[87] decodedPacket3_i[86]
+ decodedPacket3_i[85] decodedPacket3_i[84] decodedPacket3_i[83] decodedPacket3_i[82]
+ decodedPacket3_i[81] decodedPacket3_i[80] decodedPacket3_i[79] decodedPacket3_i[78]
+ decodedPacket3_i[77] decodedPacket3_i[76] decodedPacket3_i[75] decodedPacket3_i[74]
+ decodedPacket3_i[73] decodedPacket3_i[72] decodedPacket3_i[71] decodedPacket3_i[70]
+ decodedPacket3_i[69] decodedPacket3_i[68] decodedPacket3_i[67] decodedPacket3_i[66]
+ decodedPacket3_i[65] decodedPacket3_i[64] decodedPacket3_i[63] decodedPacket3_i[62]
+ decodedPacket3_i[61] decodedPacket3_i[60] decodedPacket3_i[59] decodedPacket3_i[58]
+ decodedPacket3_i[57] decodedPacket3_i[56] decodedPacket3_i[55] decodedPacket3_i[54]
+ decodedPacket3_i[53] decodedPacket3_i[52] decodedPacket3_i[51] decodedPacket3_i[50]
+ decodedPacket3_i[49] decodedPacket3_i[48] decodedPacket3_i[47] decodedPacket3_i[46]
+ decodedPacket3_i[45] decodedPacket3_i[44] decodedPacket3_i[43] decodedPacket3_i[42]
+ decodedPacket3_i[41] decodedPacket3_i[40] decodedPacket3_i[39] decodedPacket3_i[38]
+ decodedPacket3_i[37] decodedPacket3_i[36] decodedPacket3_i[35] decodedPacket3_i[34]
+ decodedPacket3_i[33] decodedPacket3_i[32] decodedPacket3_i[31] decodedPacket3_i[30]
+ decodedPacket3_i[29] decodedPacket3_i[28] decodedPacket3_i[27] decodedPacket3_i[26]
+ decodedPacket3_i[25] decodedPacket3_i[24] decodedPacket3_i[23] decodedPacket3_i[22]
+ decodedPacket3_i[21] decodedPacket3_i[20] decodedPacket3_i[19] decodedPacket3_i[18]
+ decodedPacket3_i[17] decodedPacket3_i[16] decodedPacket3_i[15] decodedPacket3_i[14]
+ decodedPacket3_i[13] decodedPacket3_i[12] decodedPacket3_i[11] decodedPacket3_i[10]
+ decodedPacket3_i[9] decodedPacket3_i[8] decodedPacket3_i[7] decodedPacket3_i[6]
+ decodedPacket3_i[5] decodedPacket3_i[4] decodedPacket3_i[3] decodedPacket3_i[2]
+ decodedPacket3_i[1] decodedPacket3_i[0] decodedPacket4_i[125] decodedPacket4_i[124]
+ decodedPacket4_i[123] decodedPacket4_i[122] decodedPacket4_i[121] decodedPacket4_i[120]
+ decodedPacket4_i[119] decodedPacket4_i[118] decodedPacket4_i[117] decodedPacket4_i[116]
+ decodedPacket4_i[115] decodedPacket4_i[114] decodedPacket4_i[113] decodedPacket4_i[112]
+ decodedPacket4_i[111] decodedPacket4_i[110] decodedPacket4_i[109] decodedPacket4_i[108]
+ decodedPacket4_i[107] decodedPacket4_i[106] decodedPacket4_i[105] decodedPacket4_i[104]
+ decodedPacket4_i[103] decodedPacket4_i[102] decodedPacket4_i[101] decodedPacket4_i[100]
+ decodedPacket4_i[99] decodedPacket4_i[98] decodedPacket4_i[97] decodedPacket4_i[96]
+ decodedPacket4_i[95] decodedPacket4_i[94] decodedPacket4_i[93] decodedPacket4_i[92]
+ decodedPacket4_i[91] decodedPacket4_i[90] decodedPacket4_i[89] decodedPacket4_i[88]
+ decodedPacket4_i[87] decodedPacket4_i[86] decodedPacket4_i[85] decodedPacket4_i[84]
+ decodedPacket4_i[83] decodedPacket4_i[82] decodedPacket4_i[81] decodedPacket4_i[80]
+ decodedPacket4_i[79] decodedPacket4_i[78] decodedPacket4_i[77] decodedPacket4_i[76]
+ decodedPacket4_i[75] decodedPacket4_i[74] decodedPacket4_i[73] decodedPacket4_i[72]
+ decodedPacket4_i[71] decodedPacket4_i[70] decodedPacket4_i[69] decodedPacket4_i[68]
+ decodedPacket4_i[67] decodedPacket4_i[66] decodedPacket4_i[65] decodedPacket4_i[64]
+ decodedPacket4_i[63] decodedPacket4_i[62] decodedPacket4_i[61] decodedPacket4_i[60]
+ decodedPacket4_i[59] decodedPacket4_i[58] decodedPacket4_i[57] decodedPacket4_i[56]
+ decodedPacket4_i[55] decodedPacket4_i[54] decodedPacket4_i[53] decodedPacket4_i[52]
+ decodedPacket4_i[51] decodedPacket4_i[50] decodedPacket4_i[49] decodedPacket4_i[48]
+ decodedPacket4_i[47] decodedPacket4_i[46] decodedPacket4_i[45] decodedPacket4_i[44]
+ decodedPacket4_i[43] decodedPacket4_i[42] decodedPacket4_i[41] decodedPacket4_i[40]
+ decodedPacket4_i[39] decodedPacket4_i[38] decodedPacket4_i[37] decodedPacket4_i[36]
+ decodedPacket4_i[35] decodedPacket4_i[34] decodedPacket4_i[33] decodedPacket4_i[32]
+ decodedPacket4_i[31] decodedPacket4_i[30] decodedPacket4_i[29] decodedPacket4_i[28]
+ decodedPacket4_i[27] decodedPacket4_i[26] decodedPacket4_i[25] decodedPacket4_i[24]
+ decodedPacket4_i[23] decodedPacket4_i[22] decodedPacket4_i[21] decodedPacket4_i[20]
+ decodedPacket4_i[19] decodedPacket4_i[18] decodedPacket4_i[17] decodedPacket4_i[16]
+ decodedPacket4_i[15] decodedPacket4_i[14] decodedPacket4_i[13] decodedPacket4_i[12]
+ decodedPacket4_i[11] decodedPacket4_i[10] decodedPacket4_i[9] decodedPacket4_i[8]
+ decodedPacket4_i[7] decodedPacket4_i[6] decodedPacket4_i[5] decodedPacket4_i[4]
+ decodedPacket4_i[3] decodedPacket4_i[2] decodedPacket4_i[1] decodedPacket4_i[0]
+ decodedPacket5_i[125] decodedPacket5_i[124] decodedPacket5_i[123] decodedPacket5_i[122]
+ decodedPacket5_i[121] decodedPacket5_i[120] decodedPacket5_i[119] decodedPacket5_i[118]
+ decodedPacket5_i[117] decodedPacket5_i[116] decodedPacket5_i[115] decodedPacket5_i[114]
+ decodedPacket5_i[113] decodedPacket5_i[112] decodedPacket5_i[111] decodedPacket5_i[110]
+ decodedPacket5_i[109] decodedPacket5_i[108] decodedPacket5_i[107] decodedPacket5_i[106]
+ decodedPacket5_i[105] decodedPacket5_i[104] decodedPacket5_i[103] decodedPacket5_i[102]
+ decodedPacket5_i[101] decodedPacket5_i[100] decodedPacket5_i[99] decodedPacket5_i[98]
+ decodedPacket5_i[97] decodedPacket5_i[96] decodedPacket5_i[95] decodedPacket5_i[94]
+ decodedPacket5_i[93] decodedPacket5_i[92] decodedPacket5_i[91] decodedPacket5_i[90]
+ decodedPacket5_i[89] decodedPacket5_i[88] decodedPacket5_i[87] decodedPacket5_i[86]
+ decodedPacket5_i[85] decodedPacket5_i[84] decodedPacket5_i[83] decodedPacket5_i[82]
+ decodedPacket5_i[81] decodedPacket5_i[80] decodedPacket5_i[79] decodedPacket5_i[78]
+ decodedPacket5_i[77] decodedPacket5_i[76] decodedPacket5_i[75] decodedPacket5_i[74]
+ decodedPacket5_i[73] decodedPacket5_i[72] decodedPacket5_i[71] decodedPacket5_i[70]
+ decodedPacket5_i[69] decodedPacket5_i[68] decodedPacket5_i[67] decodedPacket5_i[66]
+ decodedPacket5_i[65] decodedPacket5_i[64] decodedPacket5_i[63] decodedPacket5_i[62]
+ decodedPacket5_i[61] decodedPacket5_i[60] decodedPacket5_i[59] decodedPacket5_i[58]
+ decodedPacket5_i[57] decodedPacket5_i[56] decodedPacket5_i[55] decodedPacket5_i[54]
+ decodedPacket5_i[53] decodedPacket5_i[52] decodedPacket5_i[51] decodedPacket5_i[50]
+ decodedPacket5_i[49] decodedPacket5_i[48] decodedPacket5_i[47] decodedPacket5_i[46]
+ decodedPacket5_i[45] decodedPacket5_i[44] decodedPacket5_i[43] decodedPacket5_i[42]
+ decodedPacket5_i[41] decodedPacket5_i[40] decodedPacket5_i[39] decodedPacket5_i[38]
+ decodedPacket5_i[37] decodedPacket5_i[36] decodedPacket5_i[35] decodedPacket5_i[34]
+ decodedPacket5_i[33] decodedPacket5_i[32] decodedPacket5_i[31] decodedPacket5_i[30]
+ decodedPacket5_i[29] decodedPacket5_i[28] decodedPacket5_i[27] decodedPacket5_i[26]
+ decodedPacket5_i[25] decodedPacket5_i[24] decodedPacket5_i[23] decodedPacket5_i[22]
+ decodedPacket5_i[21] decodedPacket5_i[20] decodedPacket5_i[19] decodedPacket5_i[18]
+ decodedPacket5_i[17] decodedPacket5_i[16] decodedPacket5_i[15] decodedPacket5_i[14]
+ decodedPacket5_i[13] decodedPacket5_i[12] decodedPacket5_i[11] decodedPacket5_i[10]
+ decodedPacket5_i[9] decodedPacket5_i[8] decodedPacket5_i[7] decodedPacket5_i[6]
+ decodedPacket5_i[5] decodedPacket5_i[4] decodedPacket5_i[3] decodedPacket5_i[2]
+ decodedPacket5_i[1] decodedPacket5_i[0] decodedPacket6_i[125] decodedPacket6_i[124]
+ decodedPacket6_i[123] decodedPacket6_i[122] decodedPacket6_i[121] decodedPacket6_i[120]
+ decodedPacket6_i[119] decodedPacket6_i[118] decodedPacket6_i[117] decodedPacket6_i[116]
+ decodedPacket6_i[115] decodedPacket6_i[114] decodedPacket6_i[113] decodedPacket6_i[112]
+ decodedPacket6_i[111] decodedPacket6_i[110] decodedPacket6_i[109] decodedPacket6_i[108]
+ decodedPacket6_i[107] decodedPacket6_i[106] decodedPacket6_i[105] decodedPacket6_i[104]
+ decodedPacket6_i[103] decodedPacket6_i[102] decodedPacket6_i[101] decodedPacket6_i[100]
+ decodedPacket6_i[99] decodedPacket6_i[98] decodedPacket6_i[97] decodedPacket6_i[96]
+ decodedPacket6_i[95] decodedPacket6_i[94] decodedPacket6_i[93] decodedPacket6_i[92]
+ decodedPacket6_i[91] decodedPacket6_i[90] decodedPacket6_i[89] decodedPacket6_i[88]
+ decodedPacket6_i[87] decodedPacket6_i[86] decodedPacket6_i[85] decodedPacket6_i[84]
+ decodedPacket6_i[83] decodedPacket6_i[82] decodedPacket6_i[81] decodedPacket6_i[80]
+ decodedPacket6_i[79] decodedPacket6_i[78] decodedPacket6_i[77] decodedPacket6_i[76]
+ decodedPacket6_i[75] decodedPacket6_i[74] decodedPacket6_i[73] decodedPacket6_i[72]
+ decodedPacket6_i[71] decodedPacket6_i[70] decodedPacket6_i[69] decodedPacket6_i[68]
+ decodedPacket6_i[67] decodedPacket6_i[66] decodedPacket6_i[65] decodedPacket6_i[64]
+ decodedPacket6_i[63] decodedPacket6_i[62] decodedPacket6_i[61] decodedPacket6_i[60]
+ decodedPacket6_i[59] decodedPacket6_i[58] decodedPacket6_i[57] decodedPacket6_i[56]
+ decodedPacket6_i[55] decodedPacket6_i[54] decodedPacket6_i[53] decodedPacket6_i[52]
+ decodedPacket6_i[51] decodedPacket6_i[50] decodedPacket6_i[49] decodedPacket6_i[48]
+ decodedPacket6_i[47] decodedPacket6_i[46] decodedPacket6_i[45] decodedPacket6_i[44]
+ decodedPacket6_i[43] decodedPacket6_i[42] decodedPacket6_i[41] decodedPacket6_i[40]
+ decodedPacket6_i[39] decodedPacket6_i[38] decodedPacket6_i[37] decodedPacket6_i[36]
+ decodedPacket6_i[35] decodedPacket6_i[34] decodedPacket6_i[33] decodedPacket6_i[32]
+ decodedPacket6_i[31] decodedPacket6_i[30] decodedPacket6_i[29] decodedPacket6_i[28]
+ decodedPacket6_i[27] decodedPacket6_i[26] decodedPacket6_i[25] decodedPacket6_i[24]
+ decodedPacket6_i[23] decodedPacket6_i[22] decodedPacket6_i[21] decodedPacket6_i[20]
+ decodedPacket6_i[19] decodedPacket6_i[18] decodedPacket6_i[17] decodedPacket6_i[16]
+ decodedPacket6_i[15] decodedPacket6_i[14] decodedPacket6_i[13] decodedPacket6_i[12]
+ decodedPacket6_i[11] decodedPacket6_i[10] decodedPacket6_i[9] decodedPacket6_i[8]
+ decodedPacket6_i[7] decodedPacket6_i[6] decodedPacket6_i[5] decodedPacket6_i[4]
+ decodedPacket6_i[3] decodedPacket6_i[2] decodedPacket6_i[1] decodedPacket6_i[0]
+ decodedPacket7_i[125] decodedPacket7_i[124] decodedPacket7_i[123] decodedPacket7_i[122]
+ decodedPacket7_i[121] decodedPacket7_i[120] decodedPacket7_i[119] decodedPacket7_i[118]
+ decodedPacket7_i[117] decodedPacket7_i[116] decodedPacket7_i[115] decodedPacket7_i[114]
+ decodedPacket7_i[113] decodedPacket7_i[112] decodedPacket7_i[111] decodedPacket7_i[110]
+ decodedPacket7_i[109] decodedPacket7_i[108] decodedPacket7_i[107] decodedPacket7_i[106]
+ decodedPacket7_i[105] decodedPacket7_i[104] decodedPacket7_i[103] decodedPacket7_i[102]
+ decodedPacket7_i[101] decodedPacket7_i[100] decodedPacket7_i[99] decodedPacket7_i[98]
+ decodedPacket7_i[97] decodedPacket7_i[96] decodedPacket7_i[95] decodedPacket7_i[94]
+ decodedPacket7_i[93] decodedPacket7_i[92] decodedPacket7_i[91] decodedPacket7_i[90]
+ decodedPacket7_i[89] decodedPacket7_i[88] decodedPacket7_i[87] decodedPacket7_i[86]
+ decodedPacket7_i[85] decodedPacket7_i[84] decodedPacket7_i[83] decodedPacket7_i[82]
+ decodedPacket7_i[81] decodedPacket7_i[80] decodedPacket7_i[79] decodedPacket7_i[78]
+ decodedPacket7_i[77] decodedPacket7_i[76] decodedPacket7_i[75] decodedPacket7_i[74]
+ decodedPacket7_i[73] decodedPacket7_i[72] decodedPacket7_i[71] decodedPacket7_i[70]
+ decodedPacket7_i[69] decodedPacket7_i[68] decodedPacket7_i[67] decodedPacket7_i[66]
+ decodedPacket7_i[65] decodedPacket7_i[64] decodedPacket7_i[63] decodedPacket7_i[62]
+ decodedPacket7_i[61] decodedPacket7_i[60] decodedPacket7_i[59] decodedPacket7_i[58]
+ decodedPacket7_i[57] decodedPacket7_i[56] decodedPacket7_i[55] decodedPacket7_i[54]
+ decodedPacket7_i[53] decodedPacket7_i[52] decodedPacket7_i[51] decodedPacket7_i[50]
+ decodedPacket7_i[49] decodedPacket7_i[48] decodedPacket7_i[47] decodedPacket7_i[46]
+ decodedPacket7_i[45] decodedPacket7_i[44] decodedPacket7_i[43] decodedPacket7_i[42]
+ decodedPacket7_i[41] decodedPacket7_i[40] decodedPacket7_i[39] decodedPacket7_i[38]
+ decodedPacket7_i[37] decodedPacket7_i[36] decodedPacket7_i[35] decodedPacket7_i[34]
+ decodedPacket7_i[33] decodedPacket7_i[32] decodedPacket7_i[31] decodedPacket7_i[30]
+ decodedPacket7_i[29] decodedPacket7_i[28] decodedPacket7_i[27] decodedPacket7_i[26]
+ decodedPacket7_i[25] decodedPacket7_i[24] decodedPacket7_i[23] decodedPacket7_i[22]
+ decodedPacket7_i[21] decodedPacket7_i[20] decodedPacket7_i[19] decodedPacket7_i[18]
+ decodedPacket7_i[17] decodedPacket7_i[16] decodedPacket7_i[15] decodedPacket7_i[14]
+ decodedPacket7_i[13] decodedPacket7_i[12] decodedPacket7_i[11] decodedPacket7_i[10]
+ decodedPacket7_i[9] decodedPacket7_i[8] decodedPacket7_i[7] decodedPacket7_i[6]
+ decodedPacket7_i[5] decodedPacket7_i[4] decodedPacket7_i[3] decodedPacket7_i[2]
+ decodedPacket7_i[1] decodedPacket7_i[0] stallFetch_o instBufferReady_o decodedPacket0_o[125]
+ decodedPacket0_o[124] decodedPacket0_o[123] decodedPacket0_o[122] decodedPacket0_o[121]
+ decodedPacket0_o[120] decodedPacket0_o[119] decodedPacket0_o[118] decodedPacket0_o[117]
+ decodedPacket0_o[116] decodedPacket0_o[115] decodedPacket0_o[114] decodedPacket0_o[113]
+ decodedPacket0_o[112] decodedPacket0_o[111] decodedPacket0_o[110] decodedPacket0_o[109]
+ decodedPacket0_o[108] decodedPacket0_o[107] decodedPacket0_o[106] decodedPacket0_o[105]
+ decodedPacket0_o[104] decodedPacket0_o[103] decodedPacket0_o[102] decodedPacket0_o[101]
+ decodedPacket0_o[100] decodedPacket0_o[99] decodedPacket0_o[98] decodedPacket0_o[97]
+ decodedPacket0_o[96] decodedPacket0_o[95] decodedPacket0_o[94] decodedPacket0_o[93]
+ decodedPacket0_o[92] decodedPacket0_o[91] decodedPacket0_o[90] decodedPacket0_o[89]
+ decodedPacket0_o[88] decodedPacket0_o[87] decodedPacket0_o[86] decodedPacket0_o[85]
+ decodedPacket0_o[84] decodedPacket0_o[83] decodedPacket0_o[82] decodedPacket0_o[81]
+ decodedPacket0_o[80] decodedPacket0_o[79] decodedPacket0_o[78] decodedPacket0_o[77]
+ decodedPacket0_o[76] decodedPacket0_o[75] decodedPacket0_o[74] decodedPacket0_o[73]
+ decodedPacket0_o[72] decodedPacket0_o[71] decodedPacket0_o[70] decodedPacket0_o[69]
+ decodedPacket0_o[68] decodedPacket0_o[67] decodedPacket0_o[66] decodedPacket0_o[65]
+ decodedPacket0_o[64] decodedPacket0_o[63] decodedPacket0_o[62] decodedPacket0_o[61]
+ decodedPacket0_o[60] decodedPacket0_o[59] decodedPacket0_o[58] decodedPacket0_o[57]
+ decodedPacket0_o[56] decodedPacket0_o[55] decodedPacket0_o[54] decodedPacket0_o[53]
+ decodedPacket0_o[52] decodedPacket0_o[51] decodedPacket0_o[50] decodedPacket0_o[49]
+ decodedPacket0_o[48] decodedPacket0_o[47] decodedPacket0_o[46] decodedPacket0_o[45]
+ decodedPacket0_o[44] decodedPacket0_o[43] decodedPacket0_o[42] decodedPacket0_o[41]
+ decodedPacket0_o[40] decodedPacket0_o[39] decodedPacket0_o[38] decodedPacket0_o[37]
+ decodedPacket0_o[36] decodedPacket0_o[35] decodedPacket0_o[34] decodedPacket0_o[33]
+ decodedPacket0_o[32] decodedPacket0_o[31] decodedPacket0_o[30] decodedPacket0_o[29]
+ decodedPacket0_o[28] decodedPacket0_o[27] decodedPacket0_o[26] decodedPacket0_o[25]
+ decodedPacket0_o[24] decodedPacket0_o[23] decodedPacket0_o[22] decodedPacket0_o[21]
+ decodedPacket0_o[20] decodedPacket0_o[19] decodedPacket0_o[18] decodedPacket0_o[17]
+ decodedPacket0_o[16] decodedPacket0_o[15] decodedPacket0_o[14] decodedPacket0_o[13]
+ decodedPacket0_o[12] decodedPacket0_o[11] decodedPacket0_o[10] decodedPacket0_o[9]
+ decodedPacket0_o[8] decodedPacket0_o[7] decodedPacket0_o[6] decodedPacket0_o[5]
+ decodedPacket0_o[4] decodedPacket0_o[3] decodedPacket0_o[2] decodedPacket0_o[1]
+ decodedPacket0_o[0] decodedPacket1_o[125] decodedPacket1_o[124] decodedPacket1_o[123]
+ decodedPacket1_o[122] decodedPacket1_o[121] decodedPacket1_o[120] decodedPacket1_o[119]
+ decodedPacket1_o[118] decodedPacket1_o[117] decodedPacket1_o[116] decodedPacket1_o[115]
+ decodedPacket1_o[114] decodedPacket1_o[113] decodedPacket1_o[112] decodedPacket1_o[111]
+ decodedPacket1_o[110] decodedPacket1_o[109] decodedPacket1_o[108] decodedPacket1_o[107]
+ decodedPacket1_o[106] decodedPacket1_o[105] decodedPacket1_o[104] decodedPacket1_o[103]
+ decodedPacket1_o[102] decodedPacket1_o[101] decodedPacket1_o[100] decodedPacket1_o[99]
+ decodedPacket1_o[98] decodedPacket1_o[97] decodedPacket1_o[96] decodedPacket1_o[95]
+ decodedPacket1_o[94] decodedPacket1_o[93] decodedPacket1_o[92] decodedPacket1_o[91]
+ decodedPacket1_o[90] decodedPacket1_o[89] decodedPacket1_o[88] decodedPacket1_o[87]
+ decodedPacket1_o[86] decodedPacket1_o[85] decodedPacket1_o[84] decodedPacket1_o[83]
+ decodedPacket1_o[82] decodedPacket1_o[81] decodedPacket1_o[80] decodedPacket1_o[79]
+ decodedPacket1_o[78] decodedPacket1_o[77] decodedPacket1_o[76] decodedPacket1_o[75]
+ decodedPacket1_o[74] decodedPacket1_o[73] decodedPacket1_o[72] decodedPacket1_o[71]
+ decodedPacket1_o[70] decodedPacket1_o[69] decodedPacket1_o[68] decodedPacket1_o[67]
+ decodedPacket1_o[66] decodedPacket1_o[65] decodedPacket1_o[64] decodedPacket1_o[63]
+ decodedPacket1_o[62] decodedPacket1_o[61] decodedPacket1_o[60] decodedPacket1_o[59]
+ decodedPacket1_o[58] decodedPacket1_o[57] decodedPacket1_o[56] decodedPacket1_o[55]
+ decodedPacket1_o[54] decodedPacket1_o[53] decodedPacket1_o[52] decodedPacket1_o[51]
+ decodedPacket1_o[50] decodedPacket1_o[49] decodedPacket1_o[48] decodedPacket1_o[47]
+ decodedPacket1_o[46] decodedPacket1_o[45] decodedPacket1_o[44] decodedPacket1_o[43]
+ decodedPacket1_o[42] decodedPacket1_o[41] decodedPacket1_o[40] decodedPacket1_o[39]
+ decodedPacket1_o[38] decodedPacket1_o[37] decodedPacket1_o[36] decodedPacket1_o[35]
+ decodedPacket1_o[34] decodedPacket1_o[33] decodedPacket1_o[32] decodedPacket1_o[31]
+ decodedPacket1_o[30] decodedPacket1_o[29] decodedPacket1_o[28] decodedPacket1_o[27]
+ decodedPacket1_o[26] decodedPacket1_o[25] decodedPacket1_o[24] decodedPacket1_o[23]
+ decodedPacket1_o[22] decodedPacket1_o[21] decodedPacket1_o[20] decodedPacket1_o[19]
+ decodedPacket1_o[18] decodedPacket1_o[17] decodedPacket1_o[16] decodedPacket1_o[15]
+ decodedPacket1_o[14] decodedPacket1_o[13] decodedPacket1_o[12] decodedPacket1_o[11]
+ decodedPacket1_o[10] decodedPacket1_o[9] decodedPacket1_o[8] decodedPacket1_o[7]
+ decodedPacket1_o[6] decodedPacket1_o[5] decodedPacket1_o[4] decodedPacket1_o[3]
+ decodedPacket1_o[2] decodedPacket1_o[1] decodedPacket1_o[0] decodedPacket2_o[125]
+ decodedPacket2_o[124] decodedPacket2_o[123] decodedPacket2_o[122] decodedPacket2_o[121]
+ decodedPacket2_o[120] decodedPacket2_o[119] decodedPacket2_o[118] decodedPacket2_o[117]
+ decodedPacket2_o[116] decodedPacket2_o[115] decodedPacket2_o[114] decodedPacket2_o[113]
+ decodedPacket2_o[112] decodedPacket2_o[111] decodedPacket2_o[110] decodedPacket2_o[109]
+ decodedPacket2_o[108] decodedPacket2_o[107] decodedPacket2_o[106] decodedPacket2_o[105]
+ decodedPacket2_o[104] decodedPacket2_o[103] decodedPacket2_o[102] decodedPacket2_o[101]
+ decodedPacket2_o[100] decodedPacket2_o[99] decodedPacket2_o[98] decodedPacket2_o[97]
+ decodedPacket2_o[96] decodedPacket2_o[95] decodedPacket2_o[94] decodedPacket2_o[93]
+ decodedPacket2_o[92] decodedPacket2_o[91] decodedPacket2_o[90] decodedPacket2_o[89]
+ decodedPacket2_o[88] decodedPacket2_o[87] decodedPacket2_o[86] decodedPacket2_o[85]
+ decodedPacket2_o[84] decodedPacket2_o[83] decodedPacket2_o[82] decodedPacket2_o[81]
+ decodedPacket2_o[80] decodedPacket2_o[79] decodedPacket2_o[78] decodedPacket2_o[77]
+ decodedPacket2_o[76] decodedPacket2_o[75] decodedPacket2_o[74] decodedPacket2_o[73]
+ decodedPacket2_o[72] decodedPacket2_o[71] decodedPacket2_o[70] decodedPacket2_o[69]
+ decodedPacket2_o[68] decodedPacket2_o[67] decodedPacket2_o[66] decodedPacket2_o[65]
+ decodedPacket2_o[64] decodedPacket2_o[63] decodedPacket2_o[62] decodedPacket2_o[61]
+ decodedPacket2_o[60] decodedPacket2_o[59] decodedPacket2_o[58] decodedPacket2_o[57]
+ decodedPacket2_o[56] decodedPacket2_o[55] decodedPacket2_o[54] decodedPacket2_o[53]
+ decodedPacket2_o[52] decodedPacket2_o[51] decodedPacket2_o[50] decodedPacket2_o[49]
+ decodedPacket2_o[48] decodedPacket2_o[47] decodedPacket2_o[46] decodedPacket2_o[45]
+ decodedPacket2_o[44] decodedPacket2_o[43] decodedPacket2_o[42] decodedPacket2_o[41]
+ decodedPacket2_o[40] decodedPacket2_o[39] decodedPacket2_o[38] decodedPacket2_o[37]
+ decodedPacket2_o[36] decodedPacket2_o[35] decodedPacket2_o[34] decodedPacket2_o[33]
+ decodedPacket2_o[32] decodedPacket2_o[31] decodedPacket2_o[30] decodedPacket2_o[29]
+ decodedPacket2_o[28] decodedPacket2_o[27] decodedPacket2_o[26] decodedPacket2_o[25]
+ decodedPacket2_o[24] decodedPacket2_o[23] decodedPacket2_o[22] decodedPacket2_o[21]
+ decodedPacket2_o[20] decodedPacket2_o[19] decodedPacket2_o[18] decodedPacket2_o[17]
+ decodedPacket2_o[16] decodedPacket2_o[15] decodedPacket2_o[14] decodedPacket2_o[13]
+ decodedPacket2_o[12] decodedPacket2_o[11] decodedPacket2_o[10] decodedPacket2_o[9]
+ decodedPacket2_o[8] decodedPacket2_o[7] decodedPacket2_o[6] decodedPacket2_o[5]
+ decodedPacket2_o[4] decodedPacket2_o[3] decodedPacket2_o[2] decodedPacket2_o[1]
+ decodedPacket2_o[0] decodedPacket3_o[125] decodedPacket3_o[124] decodedPacket3_o[123]
+ decodedPacket3_o[122] decodedPacket3_o[121] decodedPacket3_o[120] decodedPacket3_o[119]
+ decodedPacket3_o[118] decodedPacket3_o[117] decodedPacket3_o[116] decodedPacket3_o[115]
+ decodedPacket3_o[114] decodedPacket3_o[113] decodedPacket3_o[112] decodedPacket3_o[111]
+ decodedPacket3_o[110] decodedPacket3_o[109] decodedPacket3_o[108] decodedPacket3_o[107]
+ decodedPacket3_o[106] decodedPacket3_o[105] decodedPacket3_o[104] decodedPacket3_o[103]
+ decodedPacket3_o[102] decodedPacket3_o[101] decodedPacket3_o[100] decodedPacket3_o[99]
+ decodedPacket3_o[98] decodedPacket3_o[97] decodedPacket3_o[96] decodedPacket3_o[95]
+ decodedPacket3_o[94] decodedPacket3_o[93] decodedPacket3_o[92] decodedPacket3_o[91]
+ decodedPacket3_o[90] decodedPacket3_o[89] decodedPacket3_o[88] decodedPacket3_o[87]
+ decodedPacket3_o[86] decodedPacket3_o[85] decodedPacket3_o[84] decodedPacket3_o[83]
+ decodedPacket3_o[82] decodedPacket3_o[81] decodedPacket3_o[80] decodedPacket3_o[79]
+ decodedPacket3_o[78] decodedPacket3_o[77] decodedPacket3_o[76] decodedPacket3_o[75]
+ decodedPacket3_o[74] decodedPacket3_o[73] decodedPacket3_o[72] decodedPacket3_o[71]
+ decodedPacket3_o[70] decodedPacket3_o[69] decodedPacket3_o[68] decodedPacket3_o[67]
+ decodedPacket3_o[66] decodedPacket3_o[65] decodedPacket3_o[64] decodedPacket3_o[63]
+ decodedPacket3_o[62] decodedPacket3_o[61] decodedPacket3_o[60] decodedPacket3_o[59]
+ decodedPacket3_o[58] decodedPacket3_o[57] decodedPacket3_o[56] decodedPacket3_o[55]
+ decodedPacket3_o[54] decodedPacket3_o[53] decodedPacket3_o[52] decodedPacket3_o[51]
+ decodedPacket3_o[50] decodedPacket3_o[49] decodedPacket3_o[48] decodedPacket3_o[47]
+ decodedPacket3_o[46] decodedPacket3_o[45] decodedPacket3_o[44] decodedPacket3_o[43]
+ decodedPacket3_o[42] decodedPacket3_o[41] decodedPacket3_o[40] decodedPacket3_o[39]
+ decodedPacket3_o[38] decodedPacket3_o[37] decodedPacket3_o[36] decodedPacket3_o[35]
+ decodedPacket3_o[34] decodedPacket3_o[33] decodedPacket3_o[32] decodedPacket3_o[31]
+ decodedPacket3_o[30] decodedPacket3_o[29] decodedPacket3_o[28] decodedPacket3_o[27]
+ decodedPacket3_o[26] decodedPacket3_o[25] decodedPacket3_o[24] decodedPacket3_o[23]
+ decodedPacket3_o[22] decodedPacket3_o[21] decodedPacket3_o[20] decodedPacket3_o[19]
+ decodedPacket3_o[18] decodedPacket3_o[17] decodedPacket3_o[16] decodedPacket3_o[15]
+ decodedPacket3_o[14] decodedPacket3_o[13] decodedPacket3_o[12] decodedPacket3_o[11]
+ decodedPacket3_o[10] decodedPacket3_o[9] decodedPacket3_o[8] decodedPacket3_o[7]
+ decodedPacket3_o[6] decodedPacket3_o[5] decodedPacket3_o[4] decodedPacket3_o[3]
+ decodedPacket3_o[2] decodedPacket3_o[1] decodedPacket3_o[0] branchCount_o[2] branchCount_o[1]
+ branchCount_o[0]
XU121 n107 dp_cluster_0/N30 N50 XOR2X1_RVT
XU120 dp_cluster_0/N29 n106 n107 AND2X1_RVT
XU119 n106 dp_cluster_0/N29 N49 XOR2X1_RVT
XU118 dp_cluster_0/N28 n105 n106 AND2X1_RVT
XU117 n105 dp_cluster_0/N28 N48 XOR2X1_RVT
XU116 n104 n103 n105 OR2X1_RVT
XU115 dp_cluster_0/N22 n102 n103 AND2X1_RVT
XU114 dp_cluster_0/N27 n101 n104 AND2X1_RVT
XU113 n102 dp_cluster_0/N22 n101 OR2X1_RVT
XU112 n102 n100 N47 XOR2X1_RVT
XU111 dp_cluster_0/N27 dp_cluster_0/N22 n100 XOR2X1_RVT
XU110 dp_cluster_0/N21 dp_cluster_0/N26 n102 AND2X1_RVT
XU109 dp_cluster_0/N26 dp_cluster_0/N21 N46 XOR2X1_RVT
XU108 n99 n98 dp_cluster_0/N22 OR2X1_RVT
XU107 decodedVector_i[6] decodedVector_i[7] n98 AND2X1_RVT
XU106 decodedVector_i[5] n97 n99 AND2X1_RVT
XU105 decodedVector_i[5] n97 dp_cluster_0/N21 XOR2X1_RVT
XU104 decodedVector_i[6] decodedVector_i[7] n97 XOR2X1_RVT
XU103 n96 dp_cluster_0/N15 dp_cluster_0/N30 XOR2X1_RVT
XU102 dp_cluster_0/N14 n95 n96 AND2X1_RVT
XU101 n95 dp_cluster_0/N14 dp_cluster_0/N29 XOR2X1_RVT
XU100 dp_cluster_0/N13 n94 n95 AND2X1_RVT
XU99 n94 dp_cluster_0/N13 dp_cluster_0/N28 XOR2X1_RVT
XU98 n93 n92 n94 OR2X1_RVT
XU97 dp_cluster_0/N12 n91 n92 AND2X1_RVT
XU96 dp_cluster_0/N17 n90 n93 AND2X1_RVT
XU95 n91 dp_cluster_0/N12 n90 OR2X1_RVT
XU94 n91 n89 dp_cluster_0/N27 XOR2X1_RVT
XU93 dp_cluster_0/N17 dp_cluster_0/N12 n89 XOR2X1_RVT
XU92 dp_cluster_0/N11 dp_cluster_0/N16 n91 AND2X1_RVT
XU91 dp_cluster_0/N16 dp_cluster_0/N11 dp_cluster_0/N26 XOR2X1_RVT
XU90 instCount[4] n88 dp_cluster_0/N15 XOR2X1_RVT
XU89 instCount[1] instCount[3] instCount[2] n87 n88 AND4X1_RVT
XU88 instCount[3] n86 dp_cluster_0/N14 XOR2X1_RVT
XU87 n85 instCount[2] n86 AND2X1_RVT
XU86 instCount[2] n85 dp_cluster_0/N13 XOR2X1_RVT
XU85 n87 instCount[1] n85 AND2X1_RVT
XU84 n87 instCount[1] dp_cluster_0/N12 XOR2X1_RVT
XU83 n84 n83 n87 OR2X1_RVT
XU82 instCount[0] decodedVector_i[1] n83 AND2X1_RVT
XU81 decodedVector_i[0] n82 n84 AND2X1_RVT
XU80 decodedVector_i[0] n82 dp_cluster_0/N11 XOR2X1_RVT
XU79 instCount[0] decodedVector_i[1] n82 XOR2X1_RVT
XU78 n81 n80 dp_cluster_0/N17 OR2X1_RVT
XU77 decodedVector_i[3] decodedVector_i[4] n80 AND2X1_RVT
XU76 decodedVector_i[2] n79 n81 AND2X1_RVT
XU75 decodedVector_i[2] n79 dp_cluster_0/N16 XOR2X1_RVT
XU74 decodedVector_i[3] decodedVector_i[4] n79 XOR2X1_RVT
XU73 n78 n77 N55 instcnt_f[4] MUX21X1_RVT
XU72 n76 n64 n77 OR2X1_RVT
XU71 N56 n67 n78 AND2X1_RVT
XU70 N54 N53 n76 OR2X1_RVT
XU69 n75 n74 instcnt_f[3] OR2X1_RVT
XU68 n73 N53 N54 n74 MUX21X1_RVT
XU67 N56 n66 n73 AND2X1_RVT
XU66 N54 n64 n75 AND2X1_RVT
XU65 n64 n66 instcnt_f[2] XOR2X1_RVT
XU64 n72 instCount[4] stallFetch_o OR2X1_RVT
XU63 instCount[3] n71 n72 AND2X1_RVT
XU62 instCount[0] n70 n71 OR2X1_RVT
XU61 instCount[2] instCount[1] n70 OR2X1_RVT
XU60 stallFetch_o n69 INVX1_RVT
XU59 n35 n68 INVX1_RVT
XU58 n76 n67 INVX1_RVT
XU57 N53 n66 INVX1_RVT
XU56 stall_i n65 INVX1_RVT
XU55 N56 n64 INVX1_RVT
XU54 n31 n63 INVX1_RVT
XU53 n61 n62 INVX1_RVT
XU52 N61 n61 INVX1_RVT
XU51 n59 n60 INVX1_RVT
XU50 N62 n59 INVX1_RVT
XU48 VDD branchCount_o[2] INVX1_RVT
XU46 VDD branchCount_o[1] INVX1_RVT
XU44 VDD branchCount_o[0] INVX1_RVT
XU33 decodeReady_i n69 n35 AND2X1_RVT
XU32 instCount[0] n68 n42 AND2X1_RVT
XU31 N46 n35 n43 AND2X1_RVT
XU30 n42 n43 instcnt_f[0] OR2X1_RVT
XU29 instCount[1] n68 n40 AND2X1_RVT
XU28 N47 n35 n41 AND2X1_RVT
XU27 n40 n41 instcnt_f[1] OR2X1_RVT
XU26 instCount[2] n68 n38 AND2X1_RVT
XU25 N48 n35 n39 AND2X1_RVT
XU24 n38 n39 N53 OR2X1_RVT
XU23 instCount[3] n68 n36 AND2X1_RVT
XU22 N49 n35 n37 AND2X1_RVT
XU21 n36 n37 N54 OR2X1_RVT
XU20 instCount[4] n68 n33 AND2X1_RVT
XU19 N50 n35 n34 AND2X1_RVT
XU18 n33 n34 N55 OR2X1_RVT
XU17 instCount[4] instCount[3] n32 OR2X1_RVT
XU16 instCount[2] n32 instBufferReady_o OR2X1_RVT
XU15 instBufferReady_o n65 N56 AND2X1_RVT
XU14 flush_i reset n31 OR2X1_RVT
XU13 instcnt_f[0] n63 N61 AND2X1_RVT
XU12 instcnt_f[1] n63 N62 AND2X1_RVT
XU11 instcnt_f[2] n63 N63 AND2X1_RVT
XU10 instcnt_f[3] n63 N64 AND2X1_RVT
XU9 instcnt_f[4] n63 N65 AND2X1_RVT
XinstCount_reg_4_ N65 clk instCount[4] DFFX1_RVT
XinstCount_reg_3_ N64 clk instCount[3] DFFX1_RVT
XinstCount_reg_2_ N63 clk instCount[2] DFFX1_RVT
XinstCount_reg_1_ n60 clk instCount[1] DFFX1_RVT
XinstCount_reg_0_ n62 clk instCount[0] DFFX1_RVT
.ENDS

* Nettran: AMD.64 Release B-2008.09.SP5.HF2.26004 2012/07/19
* Created:  6/06/2015  11:24
* Options: -verilog katan.v -outName katan.sp -verilog-b1 VDD -verilog-b0 GND -outType spice

Vkey0	key[0] GND 0.3v
Vkey1	key[1] GND 0.3v
Vkey2	key[2] GND 0.3v
Vkey3	key[3] GND 0.3v
Vkey4	key[4] GND 0.3v
Vkey5	key[5] GND 0.3v
Vkey6	key[6] GND 0.3v
Vkey7	key[7] GND 0.3v
Vkey8	key[8] GND 0.3v
Vkey9	key[9] GND 0.3v
Vkey10	key[10] GND 0.3v
Vkey11	key[11] GND 0.3v
Vkey12	key[12] GND 0.3v
Vkey13	key[13] GND 0.3v
Vkey14	key[14] GND 0.3v
Vkey15	key[15] GND 0.3v
Vkey16	key[16] GND 0.3v
Vkey17	key[17] GND 0.3v
Vkey18	key[18] GND 0.3v
Vkey19	key[19] GND 0.3v
Vkey20	key[20] GND 0.3v
Vkey21	key[21] GND 0.3v
Vkey22	key[22] GND 0.3v
Vkey23	key[23] GND 0.3v
Vkey24	key[24] GND 0.3v
Vkey25	key[25] GND 0.3v
Vkey26	key[26] GND 0.3v
Vkey27	key[27] GND 0.3v
Vkey28	key[28] GND 0.3v
Vkey29	key[29] GND 0.3v
Vkey30	key[30] GND 0.3v
Vkey31	key[31] GND 0.3v
Vkey32	key[32] GND 0.3v
Vkey33	key[33] GND 0.3v
Vkey34	key[34] GND 0.3v
Vkey35	key[35] GND 0.3v
Vkey36	key[36] GND 0.3v
Vkey37	key[37] GND 0.3v
Vkey38	key[38] GND 0.3v
Vkey39	key[39] GND 0.3v
Vkey40	key[40] GND 0.3v
Vkey41	key[41] GND 0.3v
Vkey42	key[42] GND 0.3v
Vkey43	key[43] GND 0.3v
Vkey44	key[44] GND 0.3v
Vkey45	key[45] GND 0.3v
Vkey46	key[46] GND 0.3v
Vkey47	key[47] GND 0.3v
Vkey48	key[48] GND 0.3v
Vkey49	key[49] GND 0.3v
Vkey50	key[50] GND 0.3v
Vkey51	key[51] GND 0.3v
Vkey52	key[52] GND 0.3v
Vkey53	key[53] GND 0.3v
Vkey54	key[54] GND 0.3v
Vkey55	key[55] GND 0.3v
Vkey56	key[56] GND 0.3v
Vkey57	key[57] GND 0.3v
Vkey58	key[58] GND 0.3v
Vkey59	key[59] GND 0.3v
Vkey60	key[60] GND 0.3v
Vkey61	key[61] GND 0.3v
Vkey62	key[62] GND 0.3v
Vkey63	key[63] GND 0.3v
Vkey64	key[64] GND 0.3v
Vkey65	key[65] GND 0.3v
Vkey66	key[66] GND 0.3v
Vkey67	key[67] GND 0.3v
Vkey68	key[68] GND 0.3v
Vkey69	key[69] GND 0.3v
Vkey70	key[70] GND 0.3v
Vkey71	key[71] GND 0.3v
Vkey72	key[72] GND 0.3v
Vkey73	key[73] GND 0.3v
Vkey74	key[74] GND 0.3v
Vkey75	key[75] GND 0.3v
Vkey76	key[76] GND 0.3v
Vkey77	key[77] GND 0.3v
Vkey78	key[78] GND 0.3v
Vkey79	key[79] GND 0.3v

Vkey0b	key[0]b GND 0.15v
Vkey1b	key[1]b GND 0.15v
Vkey2b	key[2]b GND 0.15v
Vkey3b	key[3]b GND 0.15v
Vkey4b	key[4]b GND 0.15v
Vkey5b	key[5]b GND 0.15v
Vkey6b	key[6]b GND 0.15v
Vkey7b	key[7]b GND 0.15v
Vkey8b	key[8]b GND 0.15v
Vkey9b	key[9]b GND 0.15v
Vkey10b	key[10]b GND 0.15v
Vkey11b	key[11]b GND 0.15v
Vkey12b	key[12]b GND 0.15v
Vkey13b	key[13]b GND 0.15v
Vkey14b	key[14]b GND 0.15v
Vkey15b	key[15]b GND 0.15v
Vkey16b	key[16]b GND 0.15v
Vkey17b	key[17]b GND 0.15v
Vkey18b	key[18]b GND 0.15v
Vkey19b	key[19]b GND 0.15v
Vkey20b	key[20]b GND 0.15v
Vkey21b	key[21]b GND 0.15v
Vkey22b	key[22]b GND 0.15v
Vkey23b	key[23]b GND 0.15v
Vkey24b	key[24]b GND 0.15v
Vkey25b	key[25]b GND 0.15v
Vkey26b	key[26]b GND 0.15v
Vkey27b	key[27]b GND 0.15v
Vkey28b	key[28]b GND 0.15v
Vkey29b	key[29]b GND 0.15v
Vkey30b	key[30]b GND 0.15v
Vkey31b	key[31]b GND 0.15v
Vkey32b	key[32]b GND 0.15v
Vkey33b	key[33]b GND 0.15v
Vkey34b	key[34]b GND 0.15v
Vkey35b	key[35]b GND 0.15v
Vkey36b	key[36]b GND 0.15v
Vkey37b	key[37]b GND 0.15v
Vkey38b	key[38]b GND 0.15v
Vkey39b	key[39]b GND 0.15v
Vkey40b	key[40]b GND 0.15v
Vkey41b	key[41]b GND 0.15v
Vkey42b	key[42]b GND 0.15v
Vkey43b	key[43]b GND 0.15v
Vkey44b	key[44]b GND 0.15v
Vkey45b	key[45]b GND 0.15v
Vkey46b	key[46]b GND 0.15v
Vkey47b	key[47]b GND 0.15v
Vkey48b	key[48]b GND 0.15v
Vkey49b	key[49]b GND 0.15v
Vkey50b	key[50]b GND 0.15v
Vkey51b	key[51]b GND 0.15v
Vkey52b	key[52]b GND 0.15v
Vkey53b	key[53]b GND 0.15v
Vkey54b	key[54]b GND 0.15v
Vkey55b	key[55]b GND 0.15v
Vkey56b	key[56]b GND 0.15v
Vkey57b	key[57]b GND 0.15v
Vkey58b	key[58]b GND 0.15v
Vkey59b	key[59]b GND 0.15v
Vkey60b	key[60]b GND 0.15v
Vkey61b	key[61]b GND 0.15v
Vkey62b	key[62]b GND 0.15v
Vkey63b	key[63]b GND 0.15v
Vkey64b	key[64]b GND 0.15v
Vkey65b	key[65]b GND 0.15v
Vkey66b	key[66]b GND 0.15v
Vkey67b	key[67]b GND 0.15v
Vkey68b	key[68]b GND 0.15v
Vkey69b	key[69]b GND 0.15v
Vkey70b	key[70]b GND 0.15v
Vkey71b	key[71]b GND 0.15v
Vkey72b	key[72]b GND 0.15v
Vkey73b	key[73]b GND 0.15v
Vkey74b	key[74]b GND 0.15v
Vkey75b	key[75]b GND 0.15v
Vkey76b	key[76]b GND 0.15v
Vkey77b	key[77]b GND 0.15v
Vkey78b	key[78]b GND 0.15v
Vkey79b	key[79]b GND 0.15v

Vp0	p[0] GND 0.15v
Vp1	p[1] GND 0.15v
Vp2	p[2] GND 0.15v
Vp3	p[3] GND 0.15v
Vp4	p[4] GND 0.15v
Vp5	p[5] GND 0.15v
Vp6	p[6] GND 0.15v
Vp7	p[7] GND 0.15v
Vp8	p[8] GND 0.15v
Vp9	p[9] GND 0.15v
Vp10	p[10] GND 0.15v
Vp11	p[11] GND 0.15v
Vp12	p[12] GND 0.15v
Vp13	p[13] GND 0.15v
Vp14	p[14] GND 0.15v
Vp15	p[15] GND 0.15v
Vp16	p[16] GND 0.15v
Vp17	p[17] GND 0.15v
Vp18	p[18] GND 0.15v
Vp19	p[19] GND 0.15v
Vp20	p[20] GND 0.15v
Vp21	p[21] GND 0.15v
Vp22	p[22] GND 0.15v
Vp23	p[23] GND 0.15v
Vp24	p[24] GND 0.15v
Vp25	p[25] GND 0.15v
Vp26	p[26] GND 0.15v
Vp27	p[27] GND 0.15v
Vp28	p[28] GND 0.15v
Vp29	p[29] GND 0.15v
Vp30	p[30] GND 0.15v
Vp31	p[31] GND 0.15v

Vp0b	p[0]b GND 0.3v
Vp1b	p[1]b GND 0.3v
Vp2b	p[2]b GND 0.3v
Vp3b	p[3]b GND 0.3v
Vp4b	p[4]b GND 0.3v
Vp5b	p[5]b GND 0.3v
Vp6b	p[6]b GND 0.3v
Vp7b	p[7]b GND 0.3v
Vp8b	p[8]b GND 0.3v
Vp9b	p[9]b GND 0.3v
Vp10b	p[10]b GND 0.3v
Vp11b	p[11]b GND 0.3v
Vp12b	p[12]b GND 0.3v
Vp13b	p[13]b GND 0.3v
Vp14b	p[14]b GND 0.3v
Vp15b	p[15]b GND 0.3v
Vp16b	p[16]b GND 0.3v
Vp17b	p[17]b GND 0.3v
Vp18b	p[18]b GND 0.3v
Vp19b	p[19]b GND 0.3v
Vp20b	p[20]b GND 0.3v
Vp21b	p[21]b GND 0.3v
Vp22b	p[22]b GND 0.3v
Vp23b	p[23]b GND 0.3v
Vp24b	p[24]b GND 0.3v
Vp25b	p[25]b GND 0.3v
Vp26b	p[26]b GND 0.3v
Vp27b	p[27]b GND 0.3v
Vp28b	p[28]b GND 0.3v
Vp29b	p[29]b GND 0.3v
Vp30b	p[30]b GND 0.3v
Vp31b	p[31]b GND 0.3v

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: OR2_X1                                                               *
*******************************************************************************
.subckt OR2_X1 A B Ab Bb Vrp Vtail Y Yb
Xp1 Yb Vrp VDD PTFET w=0.02
Xp2 Y  Vrp VDD PTFET w=0.02
Xn1 Yb B   1   NTFET w=0.02
Xn2 Y  Bb  1   NTFET w=0.02
Xn3 1  B   3   NTFET w=0.02
Xn4 Yb A   2   NTFET w=0.02
Xn5 Y  Ab  2   NTFET w=0.02
Xn6 2  Bb  3   NTFET w=0.02
Xn7 3  Vtail GND NTFET w=0.02
.ends

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: NAND2_X1                                                             *
*******************************************************************************
.subckt NAND2_X1 A B Ab Bb Vrp Vtail Y Yb
* NAND2
Xp1 Y1  Vrp VDD PTFET w=0.02
Xp2 Y1b Vrp VDD PTFET w=0.02
Xn1 Y1  B   1   NTFET w=0.02
Xn2 Y1b Bb  1   NTFET w=0.02
Xn3 1   A   3   NTFET w=0.02
Xn4 Y1  A   2   NTFET w=0.02
Xn5 Y1b Ab  2   NTFET w=0.02
Xn6 2   Ab  3   NTFET w=0.02
Xn7 3  Vtail GND NTFET w=0.02
* buffer
Xbp4 Yb Vrp VDD PTFET W=0.025
Xbp5 Y  Vrp VDD PTFET W=0.025
Xbn4 Yb Y1  4   NTFET W=0.02
Xbn5 Y  Y1b 4   NTFET W=0.02
Xbn6 4  Vtail GND NTFET W=0.02
.ends NAND2_X1

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: AND2_X1                                                              *
*******************************************************************************
.subckt AND2_X1 A B Ab Bb Vrp Vtail Y Yb
* AND2
Xp1 Y1b Vrp VDD PTFET w=0.02
Xp2 Y1  Vrp VDD PTFET w=0.02
Xn1 Y1b B   1   NTFET w=0.02
Xn2 Y1  Bb  1   NTFET w=0.02
Xn3 1   A   3   NTFET w=0.02
Xn4 Y1b A   2   NTFET w=0.02
Xn5 Y1  Ab  2   NTFET w=0.02
Xn6 2   Ab  3   NTFET w=0.02
Xn7 3   Vtail GND NTFET w=0.02
* buffer
Xbp1 Y2b Vrp VDD PTFET W=0.026
Xbp2 Y2  Vrp VDD PTFET W=0.026
Xbn1 Y2b Y1  4   NTFET W=0.02
Xbn2 Y2  Y1b 4   NTFET W=0.02
Xbn3 4  Vtail GND NTFET W=0.02
* buffer
Xbp4 Yb Vrp VDD PTFET W=0.025
Xbp5 Y  Vrp VDD PTFET W=0.025
Xbn4 Yb Y2  5   NTFET W=0.02
Xbn5 Y  Y2b 5   NTFET W=0.02
Xbn6 5  Vtail GND NTFET W=0.02
.ends

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: AND2_X2                                                              *
*******************************************************************************
.subckt AND2_X2 A B Ab Bb Vrp Vtail Y Yb
* AND2
Xp1 Y1b Vrp VDD PTFET w=0.04
Xp2 Y1  Vrp VDD PTFET w=0.04
Xn1 Y1b B   1   NTFET w=0.04
Xn2 Y1  Bb  1   NTFET w=0.04
Xn3 1   A   3   NTFET w=0.04
Xn4 Y1b A   2   NTFET w=0.04
Xn5 Y1  Ab  2   NTFET w=0.04
Xn6 2   Ab  3   NTFET w=0.04
Xn7 3   Vtail GND NTFET w=0.04
* buffer
Xbp1 Y2b Vrp VDD PTFET W=0.026
Xbp2 Y2  Vrp VDD PTFET W=0.026
Xbn1 Y2b Y1  4   NTFET W=0.02
Xbn2 Y2  Y1b 4   NTFET W=0.02
Xbn3 4  Vtail GND NTFET W=0.02
* buffer
Xbp4 Yb Vrp VDD PTFET W=0.025
Xbp5 Y  Vrp VDD PTFET W=0.025
Xbn4 Yb Y2  5   NTFET W=0.02
Xbn5 Y  Y2b 5   NTFET W=0.02
Xbn6 5  Vtail GND NTFET W=0.02
.ends

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: AND4_X1                                                              *
*******************************************************************************
.subckt AND4_X1 A B C D Ab Bb Cb Db Vrp Vtail Y Yb
X1 A B Ab Bb Vrp Vtail out1 out1b AND2_X1
*X2 out1 out1b Vrp Vtail out3 out3b BUF_X1
X3 C D Cb Db Vrp Vtail out2 out2b AND2_X1
*X4 out2 out2b Vrp Vtail out4 out4b BUF_X1
X5 out1 out2 out1b out2b Vrp Vtail Y Yb AND2_X1
*X6 out5 out5b Vrp Vtail out6 out6b BUF_X1
*X7 out6 out6b Vrp Vtail Y Yb BUF_X1
.ends

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: INV_X1                                                               *
*******************************************************************************
.subckt INV_X1 IN INb Vrp Vtail Y Yb
Xp1 Y  Vrp VDD PTFET W=0.025
Xp2 Yb Vrp VDD PTFET W=0.025
Xn1 Y  IN  1   NTFET W=0.02
Xn2 Yb INb 1   NTFET W=0.02
Xn3 1  Vtail GND NTFET W=0.02
.ends INV_X1

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: XOR2_X1                                                              *
*******************************************************************************
.subckt XOR2_X1 A B Ab Bb Vrp Vtail Y Yb
Xp1 Yb Vrp VDD PTFET w=0.02
Xp2 Y  Vrp VDD PTFET w=0.02
Xn1 Y  B   1   NTFET w=0.02
Xn2 Yb Bb  1   NTFET w=0.02
Xn3 1  A   3   NTFET w=0.028
Xn4 Y  Bb  2   NTFET w=0.02
Xn5 Yb B   2   NTFET w=0.02
Xn6 2  Ab  3   NTFET w=0.028
Xn7 3  Vtail GND NTFET w=0.02
.ends

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: DLATCH_X1                                                            *
*******************************************************************************
.subckt DLATCH_X1 D Db CLK CLKb Vrp Vtail Q Qb
Xp1 Qb Vrp VDD PTFET w=0.02
Xp2 Q  Vrp VDD PTFET w=0.02
Xn1 Qb D   1   NTFET w=0.02
Xn2 Q  Db  1   NTFET w=0.02
Xn3 1  CLKb 3   NTFET w=0.022
Xn4 Qb Q   2   NTFET w=0.02
Xn5 Q  Qb  2   NTFET w=0.02
Xn6 2  CLK 3   NTFET w=0.022
Xn7 3  Vtail GND NTFET w=0.02
.ends DLATCH_X1

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: DFF_X1                                                               *
*******************************************************************************
.subckt DFF_X1 D Db CLK CLKb Vrp Vtail Q Qb
X_dlatch1 D  Db  CLK  CLKb Vrp  Vtail Qm Qmb DLATCH_X1
X_dlatch2 Qm Qmb CLKb CLK  Vrp  Vtail Q  Qb  DLATCH_X1
.ends DFF_X1

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: MUX2_X1                                                              *
*******************************************************************************
.subckt MUX2_X1 A B Ab Bb SEL SELb Vrp Vtail Y Yb
Xp1 Y  Vrp VDD PTFET w=0.02
Xp2 Yb Vrp VDD PTFET w=0.02
Xn1 Yb A   1   NTFET w=0.02
Xn2 Y  Ab  1   NTFET w=0.02
Xn3 1  SELb 3   NTFET w=0.02
Xn4 Yb B   2   NTFET w=0.02
Xn5 Y  Bb  2   NTFET w=0.02
Xn6 2  SEL  3   NTFET w=0.02
Xn7 3  Vtail GND NTFET w=0.02
.ends

*******************************************************************************
* Sub-Circuit Netlist:                                                        *
* Block: NMUX2_X1                                                             *
*******************************************************************************
.subckt NMUX2_X1 A B Ab Bb SEL SELb Vrp Vtail Y Yb
Xp1 Yb Vrp VDD PTFET w=0.02
Xp2 Y  Vrp VDD PTFET w=0.02
Xn1 Y  A   1   NTFET w=0.02
Xn2 Yb Ab  1   NTFET w=0.02
Xn3 1  SELb 3  NTFET w=0.02
Xn4 Y  B   2   NTFET w=0.02
Xn5 Yb Bb  2   NTFET w=0.02
Xn6 2  SEL 3   NTFET w=0.02
Xn7 3  Vtail GND NTFET w=0.02
.ends

*******************************************************************************
* Main Circuit Netlist:                                                       *
* Block: KATAN                                                                *
*******************************************************************************

.SUBCKT katan clk clkb start startb p[31] p[30] p[29] p[28] p[27] p[26] p[25] p[24] p[23] p[22]
+ p[21] p[20] p[19] p[18] p[17] p[16] p[15] p[14] p[13] p[12] p[11] p[10] p[9] p[8]
+ p[7] p[6] p[5] p[4] p[3] p[2] p[1] p[0]
+ p[31]b p[30]b p[29]b p[28]b p[27]b p[26]b p[25]b p[24]b p[23]b p[22]b p[21]b
+ p[20]b p[19]b p[18]b p[17]b p[16]b p[15]b p[14]b p[13]b p[12]b p[11]b p[10]b
+ p[9]b p[8]b p[7]b p[6]b p[5]b p[4]b p[3]b p[2]b p[1]b p[0]b
+ key[79] key[78] key[77] key[76] key[75] key[74] key[73] key[72] key[71] key[70]
+ key[69] key[68] key[67] key[66] key[65] key[64] key[63] key[62] key[61] key[60]
+ key[59] key[58] key[57] key[56] key[55] key[54] key[53] key[52] key[51] key[50]
+ key[49] key[48] key[47] key[46] key[45] key[44] key[43] key[42] key[41] key[40]
+ key[39] key[38] key[37] key[36] key[35] key[34] key[33] key[32] key[31] key[30]
+ key[29] key[28] key[27] key[26] key[25] key[24] key[23] key[22] key[21] key[20]
+ key[19] key[18] key[17] key[16] key[15] key[14] key[13] key[12] key[11] key[10]
+ key[9] key[8] key[7] key[6] key[5] key[4] key[3] key[2] key[1] key[0]
+ key[79]b key[78]b key[77]b key[76]b key[75]b key[74]b key[73]b key[72]b key[71]b key[70]b
+ key[69]b key[68]b key[67]b key[66]b key[65]b key[64]b key[63]b key[62]b key[61]b key[60]b
+ key[59]b key[58]b key[57]b key[56]b key[55]b key[54]b key[53]b key[52]b key[51]b key[50]b
+ key[49]b key[48]b key[47]b key[46]b key[45]b key[44]b key[43]b key[42]b key[41]b key[40]b
+ key[39]b key[38]b key[37]b key[36]b key[35]b key[34]b key[33]b key[32]b key[31]b key[30]b
+ key[29]b key[28]b key[27]b key[26]b key[25]b key[24]b key[23]b key[22]b key[21]b key[20]b
+ key[19]b key[18]b key[17]b key[16]b key[15]b key[14]b key[13]b key[12]b key[11]b key[10]b
+ key[9]b key[8]b key[7]b key[6]b key[5]b key[4]b key[3]b key[2]b key[1]b key[0]b
+ c[31] c[30] c[29] c[28] c[27] c[26] c[25] c[24] c[23] c[22] c[21] c[20] c[19]
+ c[18] c[17] c[16] c[15] c[14] c[13] c[12] c[11] c[10] c[9] c[8] c[7] c[6]
+ c[5] c[4] c[3] c[2] c[1] c[0]
+ c[31]b c[30]b c[29]b c[28]b n386 c[26]b c[25]b n387 c[23]b c[22]b c[21]b c[20]b c[19]b
+ c[18]b c[17]b c[16]b c[15]b c[14]b c[13]b n384 c[11]b n385 c[9]b n382 c[7]b c[6]b
+ c[5]b c[4]b n383 c[2]b c[1]b c[0]b
+ cycle_254 cycle_254b vp vn
XU627 p[19] L1_sig[0] p[19]b L1_sig[0]b start startb vp vn N10 N10b MUX2_X1
XU626 key[58] key_sig[58] key[58]b key_sig[58]b start startb vp vn N100 N100b MUX2_X1
XU625 key[59] key_sig[59] key[59]b key_sig[59]b start startb vp vn N101 N101b MUX2_X1
XU624 key[60] key_sig[60] key[60]b key_sig[60]b start startb vp vn N102 N102b MUX2_X1
XU623 key[61] key_sig[61] key[61]b key_sig[61]b start startb vp vn N103 N103b MUX2_X1
XU622 key[62] key_sig[62] key[62]b key_sig[62]b start startb vp vn N104 N104b MUX2_X1
XU621 key[63] key_sig[63] key[63]b key_sig[63]b start startb vp vn N105 N105b MUX2_X1
XU620 key[64] key_sig[64] key[64]b key_sig[64]b start startb vp vn N106 N106b MUX2_X1
XU619 key[65] key_sig[65] key[65]b key_sig[65]b start startb vp vn N107 N107b MUX2_X1
XU618 key[66] key_sig[66] key[66]b key_sig[66]b start startb vp vn N108 N108b MUX2_X1
XU617 key[67] key_sig[67] key[67]b key_sig[67]b start startb vp vn N109 N109b MUX2_X1
XU616 p[20] c[19] p[20]b c[19]b start startb vp vn N11 N11b MUX2_X1
XU615 key[68] key_sig[68] key[68]b key_sig[68]b start startb vp vn N110 N110b MUX2_X1
XU614 key[69] key_sig[69] key[69]b key_sig[69]b start startb vp vn N111 N111b MUX2_X1
XU613 key[70] key_sig[70] key[70]b key_sig[70]b start startb vp vn N112 N112b MUX2_X1
XU612 key[71] key_sig[71] key[71]b key_sig[71]b start startb vp vn N113 N113b MUX2_X1
XU611 key[72] key_sig[72] key[72]b key_sig[72]b start startb vp vn N114 N114b MUX2_X1
XU610 key[73] key_sig[73] key[73]b key_sig[73]b start startb vp vn N115 N115b MUX2_X1
XU609 key[74] key_sig[74] key[74]b key_sig[74]b start startb vp vn N116 N116b MUX2_X1
XU608 key[75] key_sig[75] key[75]b key_sig[75]b start startb vp vn N117 N117b MUX2_X1
XU607 key[76] key_sig[76] key[76]b key_sig[76]b start startb vp vn N118 N118b MUX2_X1
XU606 key[77] key_sig[77] key[77]b key_sig[77]b start startb vp vn N119 N119b MUX2_X1
XU605 p[21] c[20] p[21]b c[20]b start startb vp vn N12 N12b MUX2_X1
XU604 key[78] key_sig[78] key[78]b key_sig[78]b start startb vp vn N120 N120b MUX2_X1
XU603 key[79] key_sig[79] key[79]b key_sig[79]b start startb vp vn N121 N121b MUX2_X1
XU602 p[22] c[21] p[22]b c[21]b start startb vp vn N13 N13b MUX2_X1
XU601 n387 n386 c[24] c[27] vp vn n374 n374b OR2_X1
XU600 n374 n374b vp vn N132 N132b INV_X1
XU599 c[22] T[7] c[22]b T[7]b vp vn N134 N134b AND2_X1
XU598 n385 n384 c[10] c[12] vp vn n373 n373b OR2_X1
XU597 n373 n373b vp vn N137 N137b INV_X1
XU596 n383 n382 c[3] c[8] vp vn n372 n372b OR2_X1
XU595 n372 n372b vp vn N139 N139b INV_X1
XU594 p[23] c[22] p[23]b c[22]b start startb vp vn N14 N14b MUX2_X1
XU593 p[24] c[23] p[24]b c[23]b start startb vp vn N15 N15b MUX2_X1
XU592 p[25] p[25]b vp vn n371 n371b INV_X1
XU591 n371 n387 n371b c[24] start startb vp vn N16 N16b NMUX2_X1
XU590 p[26] c[25] p[26]b c[25]b start startb vp vn N17 N17b MUX2_X1
XU589 p[27] c[26] p[27]b c[26]b start startb vp vn N18 N18b MUX2_X1
XU588 p[28] p[28]b vp vn n370 n370b INV_X1
XU587 n370 n386 n370b c[27] start startb vp vn N19 N19b NMUX2_X1
XU586 T_sig[0] start T_sig[0]b startb vp vn N2 N2b AND2_X1
XU585 p[29] c[28] p[29]b c[28]b start startb vp vn N20 N20b MUX2_X1
XU584 p[30] c[29] p[30]b c[29]b start startb vp vn N21 N21b MUX2_X1
XU583 p[31] c[30] p[31]b c[30]b start startb vp vn N22 N22b MUX2_X1
XU582 p[0] L2_sig[0] p[0]b L2_sig[0]b start startb vp vn N23 N23b MUX2_X1
XU581 p[1] c[0] p[1]b c[0]b start startb vp vn N24 N24b MUX2_X1
XU580 p[2] c[1] p[2]b c[1]b start startb vp vn N25 N25b MUX2_X1
XU579 p[3] c[2] p[3]b c[2]b start startb vp vn N26 N26b MUX2_X1
XU578 p[4] p[4]b vp vn n369 n369b INV_X1
XU577 n369 n383 n369b c[3] start startb vp vn N27 N27b NMUX2_X1
XU576 p[5] c[4] p[5]b c[4]b start startb vp vn N28 N28b MUX2_X1
XU575 p[6] c[5] p[6]b c[5]b start startb vp vn N29 N29b MUX2_X1
XU574 n381 start n363 startb vp vn N3 N3b NAND2_X1
XU573 p[7] c[6] p[7]b c[6]b start startb vp vn N30 N30b MUX2_X1
XU572 p[8] c[7] p[8]b c[7]b start startb vp vn N31 N31b MUX2_X1
XU571 p[9] p[9]b vp vn n368 n368b INV_X1
XU570 n368 n382 n368b c[8] start startb vp vn N32 N32b NMUX2_X1
XU569 p[10] c[9] p[10]b c[9]b start startb vp vn N33 N33b MUX2_X1
XU568 p[11] p[11]b vp vn n367 n367b INV_X1
XU567 n367 n385 n367b c[10] start startb vp vn N34 N34b NMUX2_X1
XU566 p[12] c[11] p[12]b c[11]b start startb vp vn N35 N35b MUX2_X1
XU565 p[13] p[13]b vp vn n366 n366b INV_X1
XU564 n366 n384 n366b c[12] start startb vp vn N36 N36b NMUX2_X1
XU563 p[14] c[13] p[14]b c[13]b start startb vp vn N37 N37b MUX2_X1
XU562 p[15] c[14] p[15]b c[14]b start startb vp vn N38 N38b MUX2_X1
XU561 p[16] c[15] p[16]b c[15]b start startb vp vn N39 N39b MUX2_X1
XU560 n380 start n361 startb vp vn N4 N4b NAND2_X1
XU559 p[17] c[16] p[17]b c[16]b start startb vp vn N40 N40b MUX2_X1
XU558 p[18] c[17] p[18]b c[17]b start startb vp vn N41 N41b MUX2_X1
XU557 key[0] key_sig[0] key[0]b key_sig[0]b start startb vp vn N42 N42b MUX2_X1
XU556 key[1] key_sig[1] key[1]b key_sig[1]b start startb vp vn N43 N43b MUX2_X1
XU555 key[2] key_sig[2] key[2]b key_sig[2]b start startb vp vn N44 N44b MUX2_X1
XU554 key[3] key_sig[3] key[3]b key_sig[3]b start startb vp vn N45 N45b MUX2_X1
XU553 key[4] key_sig[4] key[4]b key_sig[4]b start startb vp vn N46 N46b MUX2_X1
XU552 key[5] key_sig[5] key[5]b key_sig[5]b start startb vp vn N47 N47b MUX2_X1
XU551 key[6] key_sig[6] key[6]b key_sig[6]b start startb vp vn N48 N48b MUX2_X1
XU550 key[7] key_sig[7] key[7]b key_sig[7]b start startb vp vn N49 N49b MUX2_X1
XU549 n379 start T_sig[3] startb vp vn N5 N5b NAND2_X1
XU548 key[8] key_sig[8] key[8]b key_sig[8]b start startb vp vn N50 N50b MUX2_X1
XU547 key[9] key_sig[9] key[9]b key_sig[9]b start startb vp vn N51 N51b MUX2_X1
XU546 key[10] key_sig[10] key[10]b key_sig[10]b start startb vp vn N52 N52b MUX2_X1
XU545 key[11] key_sig[11] key[11]b key_sig[11]b start startb vp vn N53 N53b MUX2_X1
XU544 key[12] key_sig[12] key[12]b key_sig[12]b start startb vp vn N54 N54b MUX2_X1
XU543 key[13] key_sig[13] key[13]b key_sig[13]b start startb vp vn N55 N55b MUX2_X1
XU542 key[14] key_sig[14] key[14]b key_sig[14]b start startb vp vn N56 N56b MUX2_X1
XU541 key[15] key_sig[15] key[15]b key_sig[15]b start startb vp vn N57 N57b MUX2_X1
XU540 key[16] key_sig[16] key[16]b key_sig[16]b start startb vp vn N58 N58b MUX2_X1
XU539 key[17] key_sig[17] key[17]b key_sig[17]b start startb vp vn N59 N59b MUX2_X1
XU538 n378 start n362 startb vp vn N6 N6b NAND2_X1
XU537 key[18] key_sig[18] key[18]b key_sig[18]b start startb vp vn N60 N60b MUX2_X1
XU536 key[19] key_sig[19] key[19]b key_sig[19]b start startb vp vn N61 N61b MUX2_X1
XU535 key[20] key_sig[20] key[20]b key_sig[20]b start startb vp vn N62 N62b MUX2_X1
XU534 key[21] key_sig[21] key[21]b key_sig[21]b start startb vp vn N63 N63b MUX2_X1
XU533 key[22] key_sig[22] key[22]b key_sig[22]b start startb vp vn N64 N64b MUX2_X1
XU532 key[23] key_sig[23] key[23]b key_sig[23]b start startb vp vn N65 N65b MUX2_X1
XU531 key[24] key_sig[24] key[24]b key_sig[24]b start startb vp vn N66 N66b MUX2_X1
XU530 key[25] key_sig[25] key[25]b key_sig[25]b start startb vp vn N67 N67b MUX2_X1
XU529 key[26] key_sig[26] key[26]b key_sig[26]b start startb vp vn N68 N68b MUX2_X1
XU528 key[27] key_sig[27] key[27]b key_sig[27]b start startb vp vn N69 N69b MUX2_X1
XU527 n377 start T_sig[5] startb vp vn N7 N7b NAND2_X1
XU526 key[28] key_sig[28] key[28]b key_sig[28]b start startb vp vn N70 N70b MUX2_X1
XU525 key[29] key_sig[29] key[29]b key_sig[29]b start startb vp vn N71 N71b MUX2_X1
XU524 key[30] key_sig[30] key[30]b key_sig[30]b start startb vp vn N72 N72b MUX2_X1
XU523 key[31] key_sig[31] key[31]b key_sig[31]b start startb vp vn N73 N73b MUX2_X1
XU522 key[32] key_sig[32] key[32]b key_sig[32]b start startb vp vn N74 N74b MUX2_X1
XU521 key[33] key_sig[33] key[33]b key_sig[33]b start startb vp vn N75 N75b MUX2_X1
XU520 key[34] key_sig[34] key[34]b key_sig[34]b start startb vp vn N76 N76b MUX2_X1
XU519 key[35] key_sig[35] key[35]b key_sig[35]b start startb vp vn N77 N77b MUX2_X1
XU518 key[36] key_sig[36] key[36]b key_sig[36]b start startb vp vn N78 N78b MUX2_X1
XU517 key[37] key_sig[37] key[37]b key_sig[37]b start startb vp vn N79 N79b MUX2_X1
XU516 n376 start n360 startb vp vn N8 N8b NAND2_X1
XU515 key[38] key_sig[38] key[38]b key_sig[38]b start startb vp vn N80 N80b MUX2_X1
XU514 key[39] key_sig[39] key[39]b key_sig[39]b start startb vp vn N81 N81b MUX2_X1
XU513 key[40] key_sig[40] key[40]b key_sig[40]b start startb vp vn N82 N82b MUX2_X1
XU512 key[41] key_sig[41] key[41]b key_sig[41]b start startb vp vn N83 N83b MUX2_X1
XU511 key[42] key_sig[42] key[42]b key_sig[42]b start startb vp vn N84 N84b MUX2_X1
XU510 key[43] key_sig[43] key[43]b key_sig[43]b start startb vp vn N85 N85b MUX2_X1
XU509 key[44] key_sig[44] key[44]b key_sig[44]b start startb vp vn N86 N86b MUX2_X1
XU508 key[45] key_sig[45] key[45]b key_sig[45]b start startb vp vn N87 N87b MUX2_X1
XU507 key[46] key_sig[46] key[46]b key_sig[46]b start startb vp vn N88 N88b MUX2_X1
XU506 key[47] key_sig[47] key[47]b key_sig[47]b start startb vp vn N89 N89b MUX2_X1
XU505 n375 start T_sig[7] startb vp vn N9 N9b NAND2_X1
XU504 key[48] key_sig[48] key[48]b key_sig[48]b start startb vp vn N90 N90b MUX2_X1
XU503 key[49] key_sig[49] key[49]b key_sig[49]b start startb vp vn N91 N91b MUX2_X1
XU502 key[50] key_sig[50] key[50]b key_sig[50]b start startb vp vn N92 N92b MUX2_X1
XU501 key[51] key_sig[51] key[51]b key_sig[51]b start startb vp vn N93 N93b MUX2_X1
XU500 key[52] key_sig[52] key[52]b key_sig[52]b start startb vp vn N94 N94b MUX2_X1
XU499 key[53] key_sig[53] key[53]b key_sig[53]b start startb vp vn N95 N95b MUX2_X1
XU498 key[54] key_sig[54] key[54]b key_sig[54]b start startb vp vn N96 N96b MUX2_X1
XU497 key[55] key_sig[55] key[55]b key_sig[55]b start startb vp vn N97 N97b MUX2_X1
XU496 key[56] key_sig[56] key[56]b key_sig[56]b start startb vp vn N98 N98b MUX2_X1
XU495 key[57] key_sig[57] key[57]b key_sig[57]b start startb vp vn N99 N99b MUX2_X1
XU494 T[7] n363 n361 T_sig[3] T[7]b n381 n380 n379 vp vn n364 n364b AND4_X1
XU493 n362 T_sig[5] n360 T_sig[7] n378 n377 n376 n375 vp vn n365 n365b AND4_X1
XU492 n364 n365 n364b n365b vp vn cycle_254 cycle_254b AND2_X1
XU491 n349 n348 n349b n348b vp vn key_sig[1] key_sig[1]b XOR2_X1
XU490 key_sig[51] key_sig[14] key_sig[51]b key_sig[14]b vp vn n348 n348b XOR2_X1
XU489 key_reg[79] key_sig[62] key_reg[79]b key_sig[62]b vp vn n349 n349b XOR2_X1
XU488 n351 n350 n351b n350b vp vn key_sig[0] key_sig[0]b XOR2_X1
XU487 key_sig[50] key_sig[13] key_sig[50]b key_sig[13]b vp vn n350 n350b XOR2_X1
XU486 key_reg[78] key_sig[61] key_reg[78]b key_sig[61]b vp vn n351 n351b XOR2_X1
XU485 n353 n352 n353b n352b vp vn L2_sig[0] L2_sig[0]b XOR2_X1
XU484 N134 n354 N134b n354b vp vn n352 n352b XOR2_X1
XU483 c[26] N132 c[26]b N132b vp vn n353 n353b XOR2_X1
XU482 key_reg[79] c[31] key_reg[79]b c[31]b vp vn n354 n354b XOR2_X1
XU481 n356 n355 n356b n355b vp vn L1_sig[0] L1_sig[0]b XOR2_X1
XU480 N139 n357 N139b n357b vp vn n355 n355b XOR2_X1
XU479 key_reg[78] N137 key_reg[78]b N137b vp vn n356 n356b XOR2_X1
XU478 c[18] c[7] c[18]b c[7]b vp vn n357 n357b XOR2_X1
XU477 n359 n358 n359b n358b vp vn T_sig[0] T_sig[0]b XOR2_X1
XU476 T_sig[5] T_sig[3] n377 n379 vp vn n358 n358b XOR2_X1
XU475 T[7] T_sig[7] T[7]b n375 vp vn n359 n359b XOR2_X1
XDFF[18] N41 N41b clk clkb vp vn c[18] c[18]b DFF_X1
XDFF[17] N40 N40b clk clkb vp vn c[17] c[17]b DFF_X1
XDFF[16] N39 N39b clk clkb vp vn c[16] c[16]b DFF_X1
XDFF[15] N38 N38b clk clkb vp vn c[15] c[15]b DFF_X1
XDFF[14] N37 N37b clk clkb vp vn c[14] c[14]b DFF_X1
XDFF[13] N36 N36b clk clkb vp vn c[13] c[13]b DFF_X1
XDFF[12] N35 N35b clk clkb vp vn c[12] n384 DFF_X1
XDFF[11] N34 N34b clk clkb vp vn c[11] c[11]b DFF_X1
XDFF[10] N33 N33b clk clkb vp vn c[10] n385 DFF_X1
XDFF[9] N32 N32b clk clkb vp vn c[9] c[9]b DFF_X1
XDFF[8] N31 N31b clk clkb vp vn c[8] n382 DFF_X1
XDFF[7] N30 N30b clk clkb vp vn c[7] c[7]b DFF_X1
XDFF[6] N29 N29b clk clkb vp vn c[6] c[6]b DFF_X1
XDFF[5] N28 N28b clk clkb vp vn c[5] c[5]b DFF_X1
XDFF[4] N27 N27b clk clkb vp vn c[4] c[4]b DFF_X1
XDFF[3] N26 N26b clk clkb vp vn c[3] n383 DFF_X1
XDFF[2] N25 N25b clk clkb vp vn c[2] c[2]b DFF_X1
XDFF[1] N24 N24b clk clkb vp vn c[1] c[1]b DFF_X1
XDFF[0] N23 N23b clk clkb vp vn c[0] c[0]b DFF_X1
XDFF1[12] N22 N22b clk clkb vp vn c[31] c[31]b DFF_X1
XDFF1[11] N21 N21b clk clkb vp vn c[30] c[30]b DFF_X1
XDFF1[10] N20 N20b clk clkb vp vn c[29] c[29]b DFF_X1
XDFF1[9] N19 N19b clk clkb vp vn c[28] c[28]b DFF_X1
XDFF1[8] N18 N18b clk clkb vp vn c[27] n386 DFF_X1
XDFF1[7] N17 N17b clk clkb vp vn c[26] c[26]b DFF_X1
XDFF1[6] N16 N16b clk clkb vp vn c[25] c[25]b DFF_X1
XDFF1[5] N15 N15b clk clkb vp vn c[24] n387 DFF_X1
XDFF1[4] N14 N14b clk clkb vp vn c[23] c[23]b DFF_X1
XDFF1[3] N13 N13b clk clkb vp vn c[22] c[22]b DFF_X1
XDFF1[2] N12 N12b clk clkb vp vn c[21] c[21]b DFF_X1
XDFF1[1] N11 N11b clk clkb vp vn c[20] c[20]b DFF_X1
XDFF1[0] N10 N10b clk clkb vp vn c[19] c[19]b DFF_X1
XT_reg[7] N9 N9b clk clkb vp vn T[7] T[7]b DFF_X1
XT_reg[6] N8 N8b clk clkb vp vn T_sig[7] n375 DFF_X1
XT_reg[5] N7 N7b clk clkb vp vn n360 n376 DFF_X1
XT_reg[4] N6 N6b clk clkb vp vn T_sig[5] n377 DFF_X1
XT_reg[3] N5 N5b clk clkb vp vn n362 n378 DFF_X1
XT_reg[2] N4 N4b clk clkb vp vn T_sig[3] n379 DFF_X1
XT_reg[1] N3 N3b clk clkb vp vn n361 n380 DFF_X1
XT_reg[0] N2 N2b clk clkb vp vn n363 n381 DFF_X1
Xkey_reg_reg[78] N120 N120b clk clkb vp vn key_reg[78] key_reg[78]b DFF_X1
Xkey_reg_reg[76] N118 N118b clk clkb vp vn key_sig[78] key_sig[78]b DFF_X1
Xkey_reg_reg[74] N116 N116b clk clkb vp vn key_sig[76] key_sig[76]b DFF_X1
Xkey_reg_reg[72] N114 N114b clk clkb vp vn key_sig[74] key_sig[74]b DFF_X1
Xkey_reg_reg[70] N112 N112b clk clkb vp vn key_sig[72] key_sig[72]b DFF_X1
Xkey_reg_reg[68] N110 N110b clk clkb vp vn key_sig[70] key_sig[70]b DFF_X1
Xkey_reg_reg[66] N108 N108b clk clkb vp vn key_sig[68] key_sig[68]b DFF_X1
Xkey_reg_reg[64] N106 N106b clk clkb vp vn key_sig[66] key_sig[66]b DFF_X1
Xkey_reg_reg[62] N104 N104b clk clkb vp vn key_sig[64] key_sig[64]b DFF_X1
Xkey_reg_reg[79] N121 N121b clk clkb vp vn key_reg[79] key_reg[79]b DFF_X1
Xkey_reg_reg[77] N119 N119b clk clkb vp vn key_sig[79] key_sig[79]b DFF_X1
Xkey_reg_reg[75] N117 N117b clk clkb vp vn key_sig[77] key_sig[77]b DFF_X1
Xkey_reg_reg[73] N115 N115b clk clkb vp vn key_sig[75] key_sig[75]b DFF_X1
Xkey_reg_reg[71] N113 N113b clk clkb vp vn key_sig[73] key_sig[73]b DFF_X1
Xkey_reg_reg[69] N111 N111b clk clkb vp vn key_sig[71] key_sig[71]b DFF_X1
Xkey_reg_reg[67] N109 N109b clk clkb vp vn key_sig[69] key_sig[69]b DFF_X1
Xkey_reg_reg[65] N107 N107b clk clkb vp vn key_sig[67] key_sig[67]b DFF_X1
Xkey_reg_reg[63] N105 N105b clk clkb vp vn key_sig[65] key_sig[65]b DFF_X1
Xkey_reg_reg[61] N103 N103b clk clkb vp vn key_sig[63] key_sig[63]b DFF_X1
Xkey_reg_reg[59] N101 N101b clk clkb vp vn key_sig[61] key_sig[61]b DFF_X1
Xkey_reg_reg[57] N99 N99b clk clkb vp vn key_sig[59] key_sig[59]b DFF_X1
Xkey_reg_reg[55] N97 N97b clk clkb vp vn key_sig[57] key_sig[57]b DFF_X1
Xkey_reg_reg[53] N95 N95b clk clkb vp vn key_sig[55] key_sig[55]b DFF_X1
Xkey_reg_reg[51] N93 N93b clk clkb vp vn key_sig[53] key_sig[53]b DFF_X1
Xkey_reg_reg[49] N91 N91b clk clkb vp vn key_sig[51] key_sig[51]b DFF_X1
Xkey_reg_reg[47] N89 N89b clk clkb vp vn key_sig[49] key_sig[49]b DFF_X1
Xkey_reg_reg[45] N87 N87b clk clkb vp vn key_sig[47] key_sig[47]b DFF_X1
Xkey_reg_reg[43] N85 N85b clk clkb vp vn key_sig[45] key_sig[45]b DFF_X1
Xkey_reg_reg[41] N83 N83b clk clkb vp vn key_sig[43] key_sig[43]b DFF_X1
Xkey_reg_reg[39] N81 N81b clk clkb vp vn key_sig[41] key_sig[41]b DFF_X1
Xkey_reg_reg[37] N79 N79b clk clkb vp vn key_sig[39] key_sig[39]b DFF_X1
Xkey_reg_reg[35] N77 N77b clk clkb vp vn key_sig[37] key_sig[37]b DFF_X1
Xkey_reg_reg[33] N75 N75b clk clkb vp vn key_sig[35] key_sig[35]b DFF_X1
Xkey_reg_reg[31] N73 N73b clk clkb vp vn key_sig[33] key_sig[33]b DFF_X1
Xkey_reg_reg[29] N71 N71b clk clkb vp vn key_sig[31] key_sig[31]b DFF_X1
Xkey_reg_reg[27] N69 N69b clk clkb vp vn key_sig[29] key_sig[29]b DFF_X1
Xkey_reg_reg[25] N67 N67b clk clkb vp vn key_sig[27] key_sig[27]b DFF_X1
Xkey_reg_reg[23] N65 N65b clk clkb vp vn key_sig[25] key_sig[25]b DFF_X1
Xkey_reg_reg[21] N63 N63b clk clkb vp vn key_sig[23] key_sig[23]b DFF_X1
Xkey_reg_reg[19] N61 N61b clk clkb vp vn key_sig[21] key_sig[21]b DFF_X1
Xkey_reg_reg[17] N59 N59b clk clkb vp vn key_sig[19] key_sig[19]b DFF_X1
Xkey_reg_reg[15] N57 N57b clk clkb vp vn key_sig[17] key_sig[17]b DFF_X1
Xkey_reg_reg[13] N55 N55b clk clkb vp vn key_sig[15] key_sig[15]b DFF_X1
Xkey_reg_reg[11] N53 N53b clk clkb vp vn key_sig[13] key_sig[13]b DFF_X1
Xkey_reg_reg[9] N51 N51b clk clkb vp vn key_sig[11] key_sig[11]b DFF_X1
Xkey_reg_reg[7] N49 N49b clk clkb vp vn key_sig[9] key_sig[9]b DFF_X1
Xkey_reg_reg[5] N47 N47b clk clkb vp vn key_sig[7] key_sig[7]b DFF_X1
Xkey_reg_reg[3] N45 N45b clk clkb vp vn key_sig[5] key_sig[5]b DFF_X1
Xkey_reg_reg[1] N43 N43b clk clkb vp vn key_sig[3] key_sig[3]b DFF_X1
Xkey_reg_reg[60] N102 N102b clk clkb vp vn key_sig[62] key_sig[62]b DFF_X1
Xkey_reg_reg[58] N100 N100b clk clkb vp vn key_sig[60] key_sig[60]b DFF_X1
Xkey_reg_reg[56] N98 N98b clk clkb vp vn key_sig[58] key_sig[58]b DFF_X1
Xkey_reg_reg[54] N96 N96b clk clkb vp vn key_sig[56] key_sig[56]b DFF_X1
Xkey_reg_reg[52] N94 N94b clk clkb vp vn key_sig[54] key_sig[54]b DFF_X1
Xkey_reg_reg[50] N92 N92b clk clkb vp vn key_sig[52] key_sig[52]b DFF_X1
Xkey_reg_reg[48] N90 N90b clk clkb vp vn key_sig[50] key_sig[50]b DFF_X1
Xkey_reg_reg[46] N88 N88b clk clkb vp vn key_sig[48] key_sig[48]b DFF_X1
Xkey_reg_reg[44] N86 N86b clk clkb vp vn key_sig[46] key_sig[46]b DFF_X1
Xkey_reg_reg[42] N84 N84b clk clkb vp vn key_sig[44] key_sig[44]b DFF_X1
Xkey_reg_reg[40] N82 N82b clk clkb vp vn key_sig[42] key_sig[42]b DFF_X1
Xkey_reg_reg[38] N80 N80b clk clkb vp vn key_sig[40] key_sig[40]b DFF_X1
Xkey_reg_reg[36] N78 N78b clk clkb vp vn key_sig[38] key_sig[38]b DFF_X1
Xkey_reg_reg[34] N76 N76b clk clkb vp vn key_sig[36] key_sig[36]b DFF_X1
Xkey_reg_reg[32] N74 N74b clk clkb vp vn key_sig[34] key_sig[34]b DFF_X1
Xkey_reg_reg[30] N72 N72b clk clkb vp vn key_sig[32] key_sig[32]b DFF_X1
Xkey_reg_reg[28] N70 N70b clk clkb vp vn key_sig[30] key_sig[30]b DFF_X1
Xkey_reg_reg[26] N68 N68b clk clkb vp vn key_sig[28] key_sig[28]b DFF_X1
Xkey_reg_reg[24] N66 N66b clk clkb vp vn key_sig[26] key_sig[26]b DFF_X1
Xkey_reg_reg[22] N64 N64b clk clkb vp vn key_sig[24] key_sig[24]b DFF_X1
Xkey_reg_reg[20] N62 N62b clk clkb vp vn key_sig[22] key_sig[22]b DFF_X1
Xkey_reg_reg[18] N60 N60b clk clkb vp vn key_sig[20] key_sig[20]b DFF_X1
Xkey_reg_reg[16] N58 N58b clk clkb vp vn key_sig[18] key_sig[18]b DFF_X1
Xkey_reg_reg[14] N56 N56b clk clkb vp vn key_sig[16] key_sig[16]b DFF_X1
Xkey_reg_reg[12] N54 N54b clk clkb vp vn key_sig[14] key_sig[14]b DFF_X1
Xkey_reg_reg[10] N52 N52b clk clkb vp vn key_sig[12] key_sig[12]b DFF_X1
Xkey_reg_reg[8] N50 N50b clk clkb vp vn key_sig[10] key_sig[10]b DFF_X1
Xkey_reg_reg[6] N48 N48b clk clkb vp vn key_sig[8] key_sig[8]b DFF_X1
Xkey_reg_reg[4] N46 N46b clk clkb vp vn key_sig[6] key_sig[6]b DFF_X1
Xkey_reg_reg[2] N44 N44b clk clkb vp vn key_sig[4] key_sig[4]b DFF_X1
Xkey_reg_reg[0] N42 N42b clk clkb vp vn key_sig[2] key_sig[2]b DFF_X1
.ENDS katan

Xkatan clk clkb start startb p[31] p[30] p[29] p[28] p[27] p[26] p[25] p[24] p[23] p[22]
+ p[21] p[20] p[19] p[18] p[17] p[16] p[15] p[14] p[13] p[12] p[11] p[10] p[9] p[8]
+ p[7] p[6] p[5] p[4] p[3] p[2] p[1] p[0]
+ p[31]b p[30]b p[29]b p[28]b p[27]b p[26]b p[25]b p[24]b p[23]b p[22]b p[21]b
+ p[20]b p[19]b p[18]b p[17]b p[16]b p[15]b p[14]b p[13]b p[12]b p[11]b p[10]b
+ p[9]b p[8]b p[7]b p[6]b p[5]b p[4]b p[3]b p[2]b p[1]b p[0]b
+ key[79] key[78] key[77] key[76] key[75] key[74] key[73] key[72] key[71] key[70]
+ key[69] key[68] key[67] key[66] key[65] key[64] key[63] key[62] key[61] key[60]
+ key[59] key[58] key[57] key[56] key[55] key[54] key[53] key[52] key[51] key[50]
+ key[49] key[48] key[47] key[46] key[45] key[44] key[43] key[42] key[41] key[40]
+ key[39] key[38] key[37] key[36] key[35] key[34] key[33] key[32] key[31] key[30]
+ key[29] key[28] key[27] key[26] key[25] key[24] key[23] key[22] key[21] key[20]
+ key[19] key[18] key[17] key[16] key[15] key[14] key[13] key[12] key[11] key[10]
+ key[9] key[8] key[7] key[6] key[5] key[4] key[3] key[2] key[1] key[0]
+ key[79]b key[78]b key[77]b key[76]b key[75]b key[74]b key[73]b key[72]b key[71]b key[70]b
+ key[69]b key[68]b key[67]b key[66]b key[65]b key[64]b key[63]b key[62]b key[61]b key[60]b
+ key[59]b key[58]b key[57]b key[56]b key[55]b key[54]b key[53]b key[52]b key[51]b key[50]b
+ key[49]b key[48]b key[47]b key[46]b key[45]b key[44]b key[43]b key[42]b key[41]b key[40]b
+ key[39]b key[38]b key[37]b key[36]b key[35]b key[34]b key[33]b key[32]b key[31]b key[30]b
+ key[29]b key[28]b key[27]b key[26]b key[25]b key[24]b key[23]b key[22]b key[21]b key[20]b
+ key[19]b key[18]b key[17]b key[16]b key[15]b key[14]b key[13]b key[12]b key[11]b key[10]b
+ key[9]b key[8]b key[7]b key[6]b key[5]b key[4]b key[3]b key[2]b key[1]b key[0]b
+ c[31] c[30] c[29] c[28] c[27] c[26] c[25] c[24] c[23] c[22] c[21] c[20] c[19]
+ c[18] c[17] c[16] c[15] c[14] c[13] c[12] c[11] c[10] c[9] c[8] c[7] c[6]
+ c[5] c[4] c[3] c[2] c[1] c[0]
+ c[31]b c[30]b c[29]b c[28]b n386 c[26]b c[25]b n387 c[23]b c[22]b c[21]b c[20]b c[19]b
+ c[18]b c[17]b c[16]b c[15]b c[14]b c[13]b n384 c[11]b n385 c[9]b n382 c[7]b c[6]b
+ c[5]b c[4]b n383 c[2]b c[1]b c[0]b
+ cycle_254 cycle_254b	Vrp Vtail katan

.GLOBAL  VDD  GND

*.include "~/home/models/PTM-MG/modelfiles/hp/20nfet.pm"
*.include "~/home/models/PTM-MG/modelfiles/hp/20pfet.pm"
*.option finesim_ouput=tr0
*.option finesim_mode=spicead
*.include "../celllist"
*.include "./includelistPTM.txt"

*.ic c[31]=0.3v c[30]=0.3v c[29]=0.3v c[28]=0.3v c[27]=0.3v c[26]=0.3v c[25]=0.3v c[24]=0.3v
*+ c[23]=0.3v c[22]=0.3v c[21]=0.3v c[20]=0.3v c[19]=0.3v c[18]=0.3v c[17]=0.3v c[16]=0.3v
*+ c[15]=0.3v c[14]=0.3v c[13]=0.3v c[12]=0.3v c[11]=0.3v c[10]=0.3v c[9]=0.3v c[8]=0.3v
*+ c[7]=0.3v c[6]=0.3v c[5]=0.3v c[4]=0.3v c[3]=0.3v c[2]=0.3v c[1]=0.3v c[0]=0.3v
*+ c[31]b=0.15v c[30]b=0.15v c[29]b=0.15v c[28]b=0.15v n386=0.15v c[26]b=0.15v c[25]b=0.15v n387=0.15v c[23]b=0.15v
*+ c[22]b=0.15v c[21]b=0.15v c[20]b=0.15v c[19]b=0.15v c[18]b=0.15v c[17]b=0.15v c[16]b=0.15v c[15]b=0.15v
*+ c[14]b=0.15v c[13]b=0.15v n384=0.15v c[11]b=0.15v n385=0.15v c[9]b=0.15v n382=0.15v c[7]b=0.15v
*+ c[6]b=0.15v c[5]b=0.15v c[4]b=0.15v n383=0.15v c[2]b=0.15v c[1]b=0.15v c[0]b=0.15v

*.include "/lhome/kavehshamsi/home/models/NDTFET/TFET/ntfet_v1.0.2.lib"
*.vec "./katanvec.vec"

VDD VDD GND 0.3v
V5 Vrp   GND 0.14v
V6 Vtail GND 0.18v

Vstart  start  GND pwl 0 0v 3ns 0v 4.001ns 0.3v 40ns 0.3v
Vstartb startb GND pwl 0 0.3v 3ns 0.3v 4.001ns 0v 40ns 0v
Vclk  clk GND pulse 0v 0.3v 1ns 0.005ns 0.005ns 5ns 10ns
Vclkb clkb GND pulse 0.3v 0v 1ns 0.005ns 0.005ns 5ns 10ns

.hdl "/lhome/shayan/KATAN_and_CML/Device_Model/PSU_TFET/InAs_TFET/InAs-NTFET-Lg-20nm.va"
.hdl "/lhome/shayan/KATAN_and_CML/Device_Model/PSU_TFET/InAs_TFET/InAs-PTFET-Lg-20nm.va"

.print i(VDD)

.options post
*.probe tran V(s[0]) V(a[0])
*.probe tran ivdd='I(VDD)'
*.tran 0.1ns 2550ns

.tran 0.1ns 2560ns

.MEAS TRAN avgval AVG i(vdd) FROM=20ns TO=27ns

.end
